# Altium project D1900511.PrjPcb (part 5 of 7)

## Sheet SqueezerFiber.SchDoc: Squeezer Fiber Connetctions
size B; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 30; SheetTotal: 37; DrawnBy: R.  Abbott; Engineer: R.  Abbott; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.09¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=7¦PrintQuality=-4¦MediaType=1¦DitherType=10¦PaperKind=11x17¦PrintScaleMode=1

### Parts
C238  Fiber Vacuum Feedthrough  DCC: D1600495  Rack: HAM7  Slot: D6-2J1
C239  Squeezer VOPO Mirror and Fiber Holder Assembly  DCC: D1700304  Rack: HAM7  Slot: VOPO Injection Platform
C240  Fiber Port Thorlabs PAF-X-5-A  DCC: T1700464  Rack: SQZT0  Slot: FC GR
C241  DCC: D1200460  Rack: ISCT0-Left  Slot: U1  (hidden comment: Patch Panel Fiber CLF/OPO/FC)  (parts A,B,C of 3)
C311  Squeezer VOPO Mirror and Fiber Holder Assembly  DCC: D1700304  Rack: HAM7  Slot: VOPO Injection Platform
C312  Squeezer VOPO Mirror and Fiber Holder Assembly  DCC: D1700304  Rack: HAM7  Slot: VOPO Injection Platform
C313  Fiber Vacuum Feedthrough  DCC: D1600495  Rack: HAM7  Slot: D6-3J1
C314  Fiber Vacuum Feedthrough  DCC: D1600495  Rack: HAM7  Slot: D6-1J1
C316  Patch Panel Fiber SQZ LO  DCC: D1700147  Rack: SQZT7-RightTop  Slot: U42
C317  Patch Panel Fiber SQZ LO  DCC: D1700147  Rack: SQZT0-Right  Slot: U35
C318  Patch Panel Fiber PSL LO  DCC: D1700175  Rack: SQZT0-Right  Slot: U34
C320  Fiber Port Thorlabs PAF-X-5-C  DCC: T1700464  Rack: SQZT0  Slot: CLF
C321  Fiber Port Thorlabs PAF-X-5-A  DCC: T1700464  Rack: SQZT0  Slot: Green Pump
C322  Fiber Port Thorlabs PAF-X-5-C  DCC: T1700464  Rack: SQZT0  Slot: Homodyne
C323  Fiber Port Thorlabs PAF-X-5-C  DCC: T1700464  Rack: SQZT0  Slot: to Homodyne
C324  Fiber Port Thorlabs PAF-X-5-C  DCC: T1700464  Rack: SQZT0  Slot: PSL LO
C325  Fiber Port Thorlabs PAF-X-5-C  DCC: T1700464  Rack: SQZT0  Slot: PSL Sample
D1100438  Patch Panel Fiber PSL Laser  DCC: D1100438  Rack: SQZT0-Right  Slot: U33

### Ports
FIBR_SQ_002 (see ISC_R4_SH1[5B])

### Nets
FIBR_SQ_002: C318.FC/APC(Fiber) ; port FIBR_SQ_002
FIBR_SQ_003: C316.FC/APC(Fiber) C317.FC/APC(Fiber)
FIBR_SQ_004: C325.FC/APC(Fiber) D1100438.FC/APC(Fiber)
FIBR_SQ_005: C318.FC/APC(Fiber) C324.FC/APC(Fiber)
FIBR_SQ_006: C317.FC/APC(Fiber) C323.FC/APC(Fiber)
FIBR_SQ_007: C316.FC/APC(Fiber) C322.FC/APC(Fiber)
FIBR_SQ_008: C241.FC/APC(OPO) C321.FC/APC(Fiber)
FIBR_SQ_009: C241.FC/APC(OPO) C320.FC/APC(Fiber)
FIBR_SQ_010: C241.FC/APC(OPO) C314.FC/APC(Air_Side)
FIBR_SQ_011: C241.FC/APC(OPO) C313.FC/APC(Air_Side)
FIBR_SQ_012: C312.FC/APC(Fiber_Launcher) C314.FC/APC(Vac._Side)
FIBR_SQ_013: C311.FC/APC(Fiber_Launcher) C313.FC/APC(Vac._Side)
FIBR_SQ_014: C238.FC/APC(Vac._Side) C239.FC/APC(Fiber_Launcher)
FIBR_SQ_015: C238.FC/APC(Air_Side) C241.FC/APC(CLF)
FIBR_SQ_016: C240.FC/APC(Fiber) C241.FC/APC(CLF)

### Layout directives
Length: 328ft: FIBR_SQ_002
Length: 50ft: FIBR_SQ_003
Length: ft: FIBR_SQ_004, FIBR_SQ_005, FIBR_SQ_006, FIBR_SQ_007, FIBR_SQ_008, FIBR_SQ_009, FIBR_SQ_010, FIBR_SQ_011, FIBR_SQ_012, FIBR_SQ_013, FIBR_SQ_014, FIBR_SQ_015, FIBR_SQ_016

### Notes on the sheet
- FC
- CLF
- OPO

### Library data of the parts
C238 C313 C314 = VacFeedFiber: Serial: Sxxxxxxx; System: ISC
C239 C311 C312 = Squeezer VOPO Mirror and Fiber Holder Assembly: Serial: Sxxxxxxx; System: ISC
C240 C320-C325 = Fiber Port Thorlabs PAF Series: Serial: Sxxxxxxx; System: ISC
C241 = Patch Panel Fiber CLF/OPO/FC: Patch Panel (D2000460); Serial: Sxxxxxxx; System: ISC
C316 C317 = Patch Panel Fiber SQZ LO: Patch Panel (D1700147); Serial: Sxxxxxxx; System: ISC
C318 = Patch Panel Fiber PSL LO: Patch Panel (D1700175); Serial: Sxxxxxxx; System: ISC
D1100438 = Patch Panel Fiber PSL Laser: Patch Panel (D1100438); Serial: Sxxxxxxx; System: ISC

## Sheet SqueezerRfDistribution.SchDoc: Squeezer RF Distribution
size C; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 31; SheetTotal: 37; DrawnBy: R.  Abbott; Engineer: R.  Abbott

### Parts
C218  DCC: D1700144  Rack: SQZT0-Left  Slot: U36  (hidden comment: Patch Panel Laser Locking)  (part B of 4)
C222  EOM3  DCC: C1700792  Rack: SQZT0  Slot: Table
C223  DCC: D1200907  Rack: SQZT0-Left  Slot: U21  (hidden comment: Patch Panel Modulator)
C224  2W RF Amp.  DCC: D1700006  Rack: SQZT0-L1  Slot: U8
C225  RF Amp Monitor  DCC: D1700020  Rack: SQZT0-L1  Slot: U7
C226  FC AOM2  DCC: E1600368????  Rack: SQZT0  Slot: Table
C227  DCC: D1700145  Rack: SQZT0-Left  Slot: U20  (hidden comment: Patch Panel AOM)  (parts A,B of 2)
C229  FC AOM1  DCC: E1600368????  Rack: SQZT0  Slot: Table
C232  RF Dist. PatchPanel  DCC: D1101479  Rack: SQZ-R2  Slot: U37
C280  EOM4  DCC: C1700792  Rack: SQZT0  Slot: Table
C286  DCC: D1200907  Rack: SQZT0-Left  Slot: U19  (hidden comment: Patch Panel Modulator)
C326  RF Dist. PatchPanel  DCC: D1101479  Rack: SQZ-R1  Slot: U41
C327  RF Dist. PatchPanel  DCC: D1101479  Rack: SQZ-R1  Slot: U39
C328  DCC: D1200907  Rack: SQZT0-Left  Slot: U34  (hidden comment: Patch Panel Modulator)
C330  DCC: D1200907  Rack: SQZT0-Left  Slot: U39  (hidden comment: Patch Panel Modulator)
C331  RF Summing Box  DCC: D040469  Rack: SQZT0  Slot: Table
C332  EOM1  DCC: C1700792  Rack: SQZT0  Slot: Table
C333  EOM2  DCC: C1700792  Rack: SQZT0  Slot: Table
C334  2W RF Amp.  DCC: D1700006  Rack: SQZT0-L1  Slot: U5
C335  RF Amp Monitor  DCC: D1700020  Rack: SQZT0-L1  Slot: U4
C336  DCC: D1700145  Rack: SQZT0-Left  Slot: U40  (hidden comment: Patch Panel AOM)  (parts A,B of 2)
C337  AOM1  DCC: E1600368  Rack: SQZT0  Slot: Table
C338  2W RF Amp.  DCC: D1700006  Rack: SQZT0-L1  Slot: U2
C339  RF Amp Monitor  DCC: D1700020  Rack: SQZT0-L1  Slot: U1
C340  AOM2  DCC: E1600368  Rack: SQZT0  Slot: Table
C341  AM modulated AOM Amplifier (IR)  DCC: D1900045  Rack: SQZ-R2  Slot: U27
C342  AM modulated AOM Amplifier (GR)  DCC: D1900045  Rack: SQZ-R2  Slot: U29
C343  DCC: D1800261  Rack: SQZT0-Left  Slot: U22  (hidden comment: Patch Panel Amplitude Modulator)
C344  SHG AOM  DCC: E1600368  Rack: SQZT0  Slot: Table
C460  RF Dist. PatchPanel  DCC: D1101479  Rack: SQZ-R2  Slot: U41
C461  RF Dist. PatchPanel  DCC: D1101479  Rack: SQZ-R2  Slot: U39
C462  RF Dist. Amp.  DCC: D1000124  Rack: SQZ-R1  Slot: U38
C463  RF Dist. Amp.  DCC: D1000124  Rack: SQZ-R2  Slot: U36

### Ports
AOM Driver GR (see SqueezerBeckhoff2[3B]), AOM Driver IR (see SqueezerBeckhoff2[3B]), ISC_SQ_11_1 (see SqueezerRfDistribution[4A]), ISC_SQ_11_1 (see SqueezerRfDistribution[4B]), ISC_SQ_11_2 (see SqueezerRfControls1[1A]), ISC_SQ_12_2 (see SqueezerRfDistribution[3B]), ISC_SQ_12_2 (see SqueezerRfDistribution[5B]), ISC_SQ_14_2 (see SqueezerRfDistribution[3B]), ISC_SQ_14_2 (see SqueezerRfDistribution[4A]), ISC_SQ_15_2 (see SqueezerRfControls1[1A]), ISC_SQ_25_2 (see SqueezerRfControls2[1A]), ISC_SQ_30_1 (see SqueezerRfDistribution[1B]), ISC_SQ_30_1 (see SqueezerRfDistribution[2A]), ISC_SQ_30_2 (see SqueezerRfControls1[2B]), ISC_SQ_31_2 (see SqueezerRfControls1[2B]), ISC_SQ_229 (see SqueezerRfControls2[6B]), ISC_SQ_326 (see SqueezerRfControls2[5B]), ISC_SQ_353 (see SqueezerRfControls2[3A]), ISC_SQ_367 (see SqueezerRfControls1[5D]), ISC_SQ_370 (see SqueezerRfControls1[4D]), ISC_SQ_402 (see SqueezerRfDistribution[3D]), ISC_SQ_402 (see SqueezerRfDistribution[4A]), ISC_SQ_419 (see ISC_C1_SH2[1A]), ISC_SQ_420 (see ISC_C1_SH2[1A]), ISC_SQ_422 (see SqueezerConcentrators[2A]), ISC_SQ_423 (see SqueezerConcentrators[2C]), ISC_SQ_424 (see SqueezerRfControls2[4A]), ISC_SQ_430_2 (see SqueezerRfControls1[4C]), ISC_SQ_432_2 (see SqueezerRfControls2[1B]), ISC_SQ_433_2 (see SqueezerRfDistribution[3B]), ISC_SQ_433_2 (see SqueezerRfDistribution[4A]), ISC_SQ_436 (see SqueezerRfDistribution[3C]), ISC_SQ_436 (see SqueezerRfDistribution[5B]), ISC_SQ_437 (see SqueezerRfControls2[6A]), ISC_SQ_438 (see SqueezerRfControls2[4A]), ISC_SQ_439 (see SqueezerRfControls2[3A]), ISC_SQ_451 (see SqueezerRfControls2[3A]), ISC_SQ_452 (see SqueezerRfControls2[3A]), ISC_SQ_455 (see SqueezerRfControls2[6B]), ISC_SQ_504 (see ISC_C3_SH3[3D]), ISC_SQ_505 (see ISC_C3_SH3[3D]), ISC_SQ_507 (see SqueezerRfControls1[2C]), ISC_SQ_510 (see SqueezerRfControls2[6B]), ISC_SQ_516 (see SqueezerRfControls1[5C]), ISC_SQ_517 (see SqueezerRfControls2[5B]), ISC_SQ_528 (see SqueezerConcentrators[1C]), ISC_SQ_531 (see SqueezerRfControls2[1B]), ISC_SQ_533, ISC_SQ_533_1, Ties to Beckhoff_, Ties to RF Controls or WFS Wiring

### Nets
ISC_SQ_11_2: C463.N(OUT_6) ; port ISC_SQ_11_2
ISC_SQ_12_2: C330.TNC C463.N(OUT_7) ; port ISC_SQ_12_2
ISC_SQ_12_3: C330.TNC C333.SMA(Input)
ISC_SQ_14_2: C328.TNC C460.N(5) ; port ISC_SQ_14_2
ISC_SQ_14_3: C328.TNC C331.SMA(RF_IN)
ISC_SQ_14_4: C331.SMA(OUT) C332.SMA(Input)
ISC_SQ_15_2: C326.N(5) ; port ISC_SQ_15_2
ISC_SQ_25_2: C326.N(4) ; port ISC_SQ_25_2
ISC_SQ_30_2: C462.N(OUT_1) ; port ISC_SQ_30_2
ISC_SQ_31_2: C462.N(OUT_2) ; port ISC_SQ_31_2
ISC_SQ_32: C334.N(Output_(2W_Max)) C335.N(IN)
ISC_SQ_229: C338.N(Input_(10dBm)) ; port ISC_SQ_229
ISC_SQ_230: C338.N(Output_(2W_Max)) C339.N(IN)
ISC_SQ_326: C339.N(CPL) ; port ISC_SQ_326
ISC_SQ_353: C335.N(CPL) ; port ISC_SQ_353
ISC_SQ_367_1: C218.SHV(EOM) ; port ISC_SQ_367
ISC_SQ_367_2: C218.SHV(EOM) C331.SMA(LF_IN)
ISC_SQ_368_1: C227.TNC(RF1) C335.N(OUT)
ISC_SQ_368_2: C227.TNC(RF1) C229.SMA/RA(Input)
ISC_SQ_369_1: C336.TNC(RF2) C339.N(OUT)
ISC_SQ_369_2: C336.TNC(RF2) C340.SMA/RA(Input)
ISC_SQ_370: C232.N(1) ; port ISC_SQ_370
ISC_SQ_402: C342.N(In_(10dBm)) C460.N(3) ; port ISC_SQ_402
ISC_SQ_403: C342.N(Out_(32dBm)) C343.TNC
ISC_SQ_404: C343.TNC C344.SMA/RA(Input)
ISC_SQ_417: C342.D37F(Controls) ; port AOM Driver GR
ISC_SQ_418: C341.D37F(Controls) ; port AOM Driver IR
ISC_SQ_419: C342.D9F(DAQ) ; port ISC_SQ_419
ISC_SQ_420: C341.D9F(DAQ) ; port ISC_SQ_420
ISC_SQ_421_1: C336.TNC(RF1) C341.N(Out_(32dBm))
ISC_SQ_421_2: C336.TNC(RF1) C337.SMA/RA(Input)
ISC_SQ_422_2: C341.TNC(Mod) ; port ISC_SQ_422
ISC_SQ_423: C342.TNC(Mod) ; port ISC_SQ_423
ISC_SQ_424: C460.N(2) ; port ISC_SQ_424
ISC_SQ_430_2: C461.N(1) ; port ISC_SQ_430_2
ISC_SQ_432_2: C326.N(3) ; port ISC_SQ_432_2
ISC_SQ_433_2: C223.TNC C460.N(6) ; port ISC_SQ_433_2
ISC_SQ_433_3: C222.SMA(Input) C223.TNC
ISC_SQ_434: C224.N(Output_(2W_Max)) C225.N(IN)
ISC_SQ_435_1: C225.N(OUT) C227.TNC(RF2)
ISC_SQ_435_2: C226.SMA/RA(Input) C227.TNC(RF2)
ISC_SQ_436: C224.N(Input_(10dBm)) C463.N(OUT_8) ; port ISC_SQ_436
ISC_SQ_437: C341.N(In_(10dBm)) ; port ISC_SQ_437
ISC_SQ_438: C462.N(OUT_3) ; port ISC_SQ_438
ISC_SQ_439: C225.N(CPL) ; port ISC_SQ_439
ISC_SQ_451: C232.N(5) ; port ISC_SQ_451
ISC_SQ_452: C232.N(6) ; port ISC_SQ_452
ISC_SQ_455: C232.N(3) ; port ISC_SQ_455
ISC_SQ_504: C462.D25F(Controls) ; port ISC_SQ_504
ISC_SQ_505: C463.D25F(Controls) ; port ISC_SQ_505
ISC_SQ_507: C327.N(1) ; port ISC_SQ_507
ISC_SQ_510: C334.N(Input_(10dBm)) ; port ISC_SQ_510
ISC_SQ_511: C326.N(1) C462.N(IN(10dBm)) ; port ISC_SQ_30_1
ISC_SQ_512: C460.N(1) C463.N(OUT_1) ; port ISC_SQ_11_1
ISC_SQ_516: C232.N(2) ; port ISC_SQ_516
ISC_SQ_517: C232.N(4) ; port ISC_SQ_517
ISC_SQ_528: C460.N(4) ; port ISC_SQ_528
ISC_SQ_531: C326.N(2) ; port ISC_SQ_531
ISC_SQ_533_1: C286.TNC C461.N(3) ; port ISC_SQ_533, port ISC_SQ_533_1
ISC_SQ_533_2: C280.SMA(Input) C286.TNC

Not connected (* = marked no-connect by the designer): C224 Conec-3(DC_+24)*; C334 Conec-3(DC_+24)*; C338 Conec-3(DC_+24)*; C341 BNC(M1)* Conec-3(DC+/-17)* Lemo 2P(Mod)*; C342 BNC(M1)* Conec-3(DC+/-17)* Lemo 2P(Mod)*; C462 BNC(M1)* Conec-3(DC+/-17)*; C463 BNC(M1)* Conec-3(DC+/-17)*

### Layout directives
Length: 8": ISC_SQ_32, ISC_SQ_230, ISC_SQ_434
Length: 54": ISC_SQ_14_3, ISC_SQ_367_2
Length: 24": ISC_SQ_367_1
Length: 6": ISC_SQ_14_4
Length: 80": ISC_SQ_12_3
Length: 36": ISC_SQ_25_2, ISC_SQ_368_1, ISC_SQ_369_1, ISC_SQ_432_2
Length: 35ft: ISC_SQ_12_2, ISC_SQ_14_2, ISC_SQ_326, ISC_SQ_353, ISC_SQ_370, ISC_SQ_403, ISC_SQ_421_1, ISC_SQ_433_2, ISC_SQ_436, ISC_SQ_439, ISC_SQ_533_1
Length: 106": ISC_SQ_421_2
Length: 124": ISC_SQ_369_2, ISC_SQ_404
Length: 55": ISC_SQ_15_2, ISC_SQ_430_2, ISC_SQ_507
Length: 18": ISC_SQ_512
Length: 12": ISC_SQ_511
Length: 60": ISC_SQ_424
Length: 68": ISC_SQ_402
Length: 96": ISC_SQ_11_2, ISC_SQ_30_2, ISC_SQ_31_2
Length: 75": ISC_SQ_433_3
Length: 42": ISC_SQ_435_1
Length: 79": ISC_SQ_435_2
Length: 83": ISC_SQ_368_2
Length: 9ft: ISC_SQ_438
Length: 66": ISC_SQ_451, ISC_SQ_452, ISC_SQ_516, ISC_SQ_517
Length: 50": ISC_SQ_455
Length: 85": ISC_SQ_528
Length: 40": ISC_SQ_531
Length: 72": ISC_SQ_533_2

### Notes on the sheet
- (near C326) RF Patch Panel 34
- 3.125MHz
- 35.5MHz
- (near C460) RF Patch Panel 36
- 80MHz
- 200MHz
- (near C232) RF Patch Panel 38
- 158.8MHz
- 79.4MHz
- (near C326) Goes to ISC-C3
- No Cable
- 6.25MHz
- 40MHz
- 24.1MHz
- (near C460) Goes to ISC-C3
- FC Beat
- (near C232) Goes to ISC-C2
- 203.125MHz
- 200.105MHz
- (near C327) Goes to ISC-R3
- (near C327) RF Patch Panel 35
- OMC DCPD
- (near C461) RF Patch Panel 37
- 71MHz
- (near C327) No Cable
- (near C461) Goes to ISC-C4
- New cables for A_ start at ISC_SQ_430
- FC EOM
- PMC EOM
- Laser Locking
- OPO EOM
- SHG EOM
- Part Number??
- FC AOM 2
- FC AOM 1
- RF cables carrying the AOM signals need to be
  1/4" superflexible helical corrugated coax.
- CLF AOM 2
- CLF AOM 1
- SHG AOM
- Key
- Dot Identifies Cable Shield Terminating to Backshell
- Pin With Triangle Indicates Pin on Rear or the Like
- Pin With No Triangle Indicates Pin on Front or the Like
- Light Blue Symbols Are In-Vacuum
- Yellow Symbols Are In-Air

### Library data of the parts
C218 = Patch Panel Laser Locking: Patch Panel (D1700144); Serial: Sxxxxxxx; System: ISC
C222 C280 C332 C333 = EOM: Serial: Sxxxxxxx; System: ISC
C223 C286 C328 C330 = Patch Panel Modulator: Patch Panel (D1200907); Serial: Sxxxxxxx; System: ISC
C224 C334 C338 = 2W RF Amp.: Serial: Sxxxxxxx; System: ISC; Frequency: 200MHz
C225 C335 C339 = RF Amp Monitor: Serial: Sxxxxxxx; System: ISC
C226 C229 C337 C340 C344 = AOM: Serial: Sxxxxxxx; System: ISC
C227 C336 = Patch Panel AOM: Patch Panel (D1700145); Serial: Sxxxxxxx; System: ISC
C232 C326 C327 C460 C461 = RF Dist. PatchPanel: Serial: Sxxxxxxx; System: ISC
C331 = RF Summing Box: Serial: Sxxxxxxx; System: ISC
C341 C342 = AM AOM V2: AM AOM; Serial: Sxxxxxxx; System: SQZ
C343 = Patch Panel Amplitude Modulator: Patch Panel (D1800261); Serial: Sxxxxxxx; System: ISC
C462 C463 = RF Distribution Amplifier: Serial: Sxxxxxxx; System: ISC

## Sheet SqueezerRfControls1.SchDoc: Squeezer RF Controls 1
size C; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 32; SheetTotal: 37; DrawnBy: R.  Abbott; Engineer: R.  Abbott

### Parts
(Parts that share a designator on the sheet are numbered #1, #2 ... from top to bottom, then left to right.)
C208  OMC/Homodyne Breakout  DCC: D1700393  Rack: SQZ-R1  Slot: U6
C216  4G TTFSS  DCC: D1700075  Rack: SQZT0-L2  Slot: U3
C217#1  Laser Locking Fiber Beat Note  DCC: D2300329  Rack: SQZT0-L2  Slot: U5
C217#2  New Focus 1611  DCC: T1700459  Rack: SQZT0  Slot: Table  (masked out: inside a compile mask, not in the netlist)
C218  Patch Panel Laser Locking  (value not drawn)  (parts A,C,D of 4)
C219  4G TTFSS Preamp  DCC: D1700324  Rack: SQZT0-L2  Slot: U1
C259  Mephisto Laser  DCC: T1700189  Rack: SQZT0-F1  Slot: U1  (parts A,B of 2)
C263  Tee  (value not drawn)
C264  Tee  (value not drawn)
C265  Tee  (value not drawn)
C266  Tee  (value not drawn)
C291  PZT  DCC: D980675  Rack: SQZT0  Slot: PMC
C296  Fiber Port Thorlabs PAF-X-5-C  DCC: T1700464  Rack: SQZT0  Slot: SQZ Sample
C346  Delay Line Phase Shifter  DCC: D0900128  Rack: SQZ-R1  Slot: U21
C347  2-Chan Demodulator  DCC: D1000181  Rack: SQZ-R1  Slot: U20
C348  Common Mode Board  DCC: D0901781  Rack: SQZ-R1  Slot: U25
C349  PZT Driver (X4)  DCC: D1001200  Rack: SQZ-R1  Slot: U14
C350  LSC Head  DCC: D1101176  Rack: SQZT0  Slot: OPO_REFL
C351  Patch Panel Dual Frequency LSC RFPD  (value not drawn)  (parts A,B,C,D,E of 5)
C352  Patch Panel TNC 1U  (value not drawn)  (parts A,B,C,D of 4)
C353  Common Mode Board  DCC: D0901781  Rack: SQZ-R1  Slot: U23
C354  Dual Dsub PatchPanel  DCC: D1201450  Rack: SQZ-R1  Slot: U15
C356  Dual Dsub PatchPanel  DCC: D1201450  Rack: SQZ-R1  Slot: U24
C357  BBPD  DCC: E1200428  Rack: SQZT0  Slot: SHG_TRANS
C358  RF Preamplifier  DCC: E1400233  Rack: SQZT0  Slot: SHG_TRANS
C359  Patch Panel Broadband PD  (value not drawn)  (parts A,B of 2)
C361  Homodyne Detector  DCC: D1300671  Rack: SQZT7
C362  Patch Panel Homodyne  (value not drawn)  (parts A,B,C,D,E of 5)
C364  2-Chan Demodulator  DCC: D1000181  Rack: SQZ-R1  Slot: U18
C365  Common Mode Board  DCC: D0901781  Rack: SQZ-R1  Slot: U16
C366  VCO  DCC: D0900605  Rack: SQZ-R2  Slot: U18
C367  X2 Freq. Mult.  DCC: D1002178  Rack: SQZ-R2  Slot: U17
C453  DCC: D1201483  Rack: SQZT0-Left  Slot: U33  (hidden comment: Patch Panel TEC Driver)
C454  DCC: D1700146  Rack: SQZT0-Left  Slot: U31  (hidden comment: Patch Panel PZT)  (parts A,B of 2)
C455  DCC: D1700146  Rack: SQZT0-Left  Slot: U41  (hidden comment: Patch Panel PZT)  (parts A,B of 2)
C456  SHG  DCC: E1700004  Rack: SQZT0  Slot: Table
C457  PZT  DCC: E1700209  Rack: SQZT0  Slot: Seed
C458  PZT  DCC: E1700209  Rack: SQZT0  Slot: LO

### Ports
Angle_RF (see SqueezerRfControls2[6D]), CLF_CM_EXE (see SqueezerRfControls2[4B]), CM_LO_A (see SqueezerBeckhoff2[3A]), CM_LO_B (see SqueezerBeckhoff2[3A]), CM_OPO_A (see SqueezerBeckhoff2[3A]), CM_OPO_B (see SqueezerBeckhoff2[3A]), CM_SHG_A (see SqueezerBeckhoff2[3A]), CM_SHG_B (see SqueezerBeckhoff2[3A]), Delay_OPO (see SqueezerBeckhoff2[3A]), Delay_SHG (see SqueezerBeckhoff2[3A]), FIBR_DC (see SqueezerConcentrators[1C]), FIBR_DC (see SqueezerConcentrators[5C], SqueezerRfControls1[3D]), FIBR_PWR (see SqueezerConcentrators[5C]), FIBR_SQ_001 (see ISC_R4_SH1[5B]), ISC_SQ_11_2 (see SqueezerRfDistribution[5B]), ISC_SQ_15_2 (see SqueezerRfDistribution[2A]), ISC_SQ_30_2 (see SqueezerRfDistribution[3B]), ISC_SQ_31_2 (see SqueezerRfDistribution[3B]), ISC_SQ_92 (see ISC_C1_SH2[4B]), ISC_SQ_93 (see ISC_C1_SH2[1B]), ISC_SQ_100 (see ISC_C1_SH1[4D]), ISC_SQ_101 (see ISC_C1_SH2[1C]), ISC_SQ_283 (see ISC_C1_SH1[4D]), ISC_SQ_287 (see ISC_C1_SH1[4D]), ISC_SQ_288 (see ISC_C1_SH2[4A]), ISC_SQ_289 (see ISC_C1_SH2[4A]), ISC_SQ_290 (see ISC_C1_SH2[4A]), ISC_SQ_292 (see ISC_C1_SH1[4C]), ISC_SQ_293 (see ISC_C1_SH1[4C]), ISC_SQ_351 (see ISC_C3_SH3[3D]), ISC_SQ_366 (see SqueezerRfControls1[2D]), ISC_SQ_366 (see SqueezerRfControls1[5C]), ISC_SQ_367 (see SqueezerRfDistribution[3B]), ISC_SQ_370 (see SqueezerRfDistribution[5A]), ISC_SQ_406 (see SqueezerRfControls2[4A]), ISC_SQ_430_2 (see SqueezerRfDistribution[4A]), ISC_SQ_472 (see SqueezerWfsWiring[3B]), ISC_SQ_473 (see SqueezerWfsWiring[3B]), ISC_SQ_474 (see SqueezerWfsWiring[3B]), ISC_SQ_475 (see SqueezerWfsWiring[3B]), ISC_SQ_507 (see SqueezerRfDistribution[2A]), ISC_SQ_513 (see SqueezerRfControls2[3A]), ISC_SQ_514 (see SqueezerRfControls2[3A]), ISC_SQ_516 (see SqueezerRfDistribution[5A]), ISC_SQ_536 (see SqueezerRfControls2[5C]), ISC_SQ_549 (see SqueezerConcentrators[1C]), ISC_SQ_552 (see SqueezerConcentrators[1D]), LASER FIBER MON (see SqueezerConcentrators[4A]), LaserDiag (see SqueezerBeckhoff2[3B]), LaserHead (see SqueezerRfControls1[1D]), LaserHead (see SqueezerRfControls1[6C]), LaserNE (see SqueezerMiscellaneous[1A]), LO_CM_EXE (see SqueezerRfControls1[4C]), LO_CM_EXE (see SqueezerRfControls1[5B]), OPO_CM_EXE (see SqueezerRfControls1[4A]), OPO_CM_EXE (see SqueezerRfControls1[5B]), OPO_DC (see SqueezerConcentrators[5D]), OPO_LSC_Head_DC (see SqueezerRfControls2[2C]), Piezo 1 (see SqueezerInVacControls[6C]), Piezo 2 (see SqueezerInVacControls[6C]), PSL FIBER MON (see SqueezerConcentrators[4C]), PZT_Driver_A (see SqueezerBeckhoff2[3B]), SHG/OPO_RF (see SqueezerRfControls2[6D]), SHG_CM_EXE (see SqueezerRfControls1[4B]), SHG_CM_EXE (see SqueezerRfControls1[5B]), SHG_DC (see SqueezerConcentrators[5C]), SHG_PWR (see SqueezerConcentrators[5C]), SHG_TEC (see SqueezerBeckhoff2[3A]), Ties_to Beckhoff, Ties_to RF Distribution, TTFSS (see SqueezerBeckhoff2[3B]), VCO_SQZ_Laser (see SqueezerBeckhoff2[3A])

### Nets
FIBR_SQ_001: C217#1.FC/APC(Fiber_PSL) ; port FIBR_SQ_001
FIBR_SQ_017: C218.FC/APC(Fiber) C296.FC/APC(Fiber)
FIBR_SQ_018: C217#1.FC/APC(Fiber_SQZ) C218.FC/APC(Fiber)
ISC_SQ_11_2: C346.TNC(Input1) ; port ISC_SQ_11_2
ISC_SQ_15_2: C346.TNC(Input2) ; port ISC_SQ_15_2
ISC_SQ_30_2: C364.TNC(LO1) ; port ISC_SQ_30_2
ISC_SQ_31_2: C364.TNC(LO2) ; port ISC_SQ_31_2
ISC_SQ_79: C349.D15F(Controls) ; port PZT_Driver_A
ISC_SQ_91: C349.TNC(IN_CH4) C354.TNC(1d)
ISC_SQ_92: C354.D9M(DSUB1) ; port ISC_SQ_92
ISC_SQ_93: C356.D9M(DSUB1) ; port ISC_SQ_93
ISC_SQ_94: C348.BNC(A-Test1) C356.TNC(1a) ; port OPO_CM_EXE
ISC_SQ_95: C353.BNC(A-Test1) C356.TNC(1b) ; port SHG_CM_EXE
ISC_SQ_96: C356.TNC(1c) C365.BNC(A-Test1) ; port LO_CM_EXE
ISC_SQ_97: C356.TNC(1d) ; port CLF_CM_EXE
ISC_SQ_98: C349.SHV(Output3) ; port Piezo 1
ISC_SQ_100: C354.D9M(DSUB2) ; port ISC_SQ_100
ISC_SQ_101: C356.D9M(DSUB2) ; port ISC_SQ_101
ISC_SQ_106: C208.D15F(Homodyne_Interface) C362.D15M(Output)
ISC_SQ_200: C346.TNC(Output1) C347.TNC(LO1)
ISC_SQ_201: C346.TNC(Output2) C347.TNC(LO2)
ISC_SQ_202_1: C350.SMA(RF_HI) C351.TNC(RFLO)
ISC_SQ_202_2: C351.TNC(RFLO) C352.TNC
ISC_SQ_202_3: C347.SMA(RFOut1) C352.TNC
ISC_SQ_203_1: C358.SMA(OUT) C359.TNC(RF1)
ISC_SQ_203_2: C352.TNC C359.TNC(RF1)
ISC_SQ_203_3: C347.SMA(RFIn2) C352.TNC
ISC_SQ_204_1: C350.SMA(RF_LO) C351.TNC(RFHI)
ISC_SQ_205_1: C350.SMA(Test_In) C351.TNC(TestIn)
ISC_SQ_206_1: C350.SMA(Test_Out) C351.TNC(TestOut)
ISC_SQ_207_1: C350.D9M(Controls) C351.D9F(Power)
ISC_SQ_207_2: C351.D9M(Power) ; port OPO_LSC_Head_DC
ISC_SQ_208: C347.TNC(I-1) C348.TNC(IN1)
ISC_SQ_209: C347.TNC(I-2) C353.TNC(IN1)
ISC_SQ_210: C365.LEMO-2P(In2) C366.Lemo_2P(Tune)
ISC_SQ_211: C366.N(Out1_(13dBm)) C367.N(IN_(10dBm))
ISC_SQ_212: C216.TNC(LO) C367.N(OUT(13dBm))
ISC_SQ_213_2: C217#1.TNC(PD_RF) C219.N(RF_IN)
ISC_SQ_217_1: C361.TNC(RF) C362.TNC(?RF)
ISC_SQ_217_2: C352.TNC C362.TNC(?RF)
ISC_SQ_217_3: C352.TNC C364.SMA(RFIn2)
ISC_SQ_218_1: C361.TNC(DC) C362.TNC(?DC)
ISC_SQ_219_1: C361.TNC(PD1) C362.TNC(PD1)
ISC_SQ_220_1: C361.TNC(PD2) C362.TNC(PD2)
ISC_SQ_221_1: C361.D15F(Controls) C362.D15M(Output)
ISC_SQ_231: C263.TNC C365.TNC(IN1)
ISC_SQ_232: C265.TNC C365.TNC(IN2)
ISC_SQ_233: C348.TNC(Slow-Out1) C349.TNC(IN_CH3)
ISC_SQ_234: C349.TNC(IN_CH1) C353.TNC(Slow-Out1)
ISC_SQ_246: C357.BNC(DC_Out) ; port SHG_DC
ISC_SQ_250: C358.M8(DC+/-15) ; port SHG_PWR
ISC_SQ_255: C350.BNC(DC) ; port OPO_DC
ISC_SQ_275: C259.M12(Relay) ; port LaserNE
ISC_SQ_283: C216.D9F(DAQ) ; port ISC_SQ_283
ISC_SQ_287: C208.D9F(Homodyne_Output) ; port ISC_SQ_287
ISC_SQ_288: C348.D9F(DAQ) ; port ISC_SQ_288
ISC_SQ_289: C353.D9F(DAQ) ; port ISC_SQ_289
ISC_SQ_290: C365.D9F(DAQ) ; port ISC_SQ_290
ISC_SQ_292: C364.D9F(DAQ) ; port ISC_SQ_292
ISC_SQ_293: C347.D9F(DAQ) ; port ISC_SQ_293
ISC_SQ_298: C366.N(VCO_(13dBm))
ISC_SQ_311: C453.D15M(TEC) ; port SHG_TEC
ISC_SQ_313: C365.D37F(Controls1) ; port CM_LO_A
ISC_SQ_314: C365.D37F(Controls2) ; port CM_LO_B
ISC_SQ_321: C216.D37F(Controls2) ; port TTFSS
ISC_SQ_325: C259.D25F(Diagnostics) ; port LaserDiag
ISC_SQ_334: C346.D25M(Controls1) ; port Delay_OPO
ISC_SQ_335: C346.D25M(Controls2) ; port Delay_SHG
ISC_SQ_336: C366.D25F(Controls) ; port VCO_SQZ_Laser
ISC_SQ_337: C348.D37F(Controls1) ; port CM_OPO_A
ISC_SQ_338: C348.D37F(Controls2) ; port CM_OPO_B
ISC_SQ_339: C353.D37F(Controls1) ; port CM_SHG_A
ISC_SQ_340: C353.D37F(Controls2) ; port CM_SHG_B
ISC_SQ_341: C216.SMA(RF_In) C219.N(Out_(HiPwr)_1)
ISC_SQ_351: C367.D25F(Controls) ; port ISC_SQ_351
ISC_SQ_358: C347.D15F(Controls) ; port SHG/OPO_RF
ISC_SQ_359: C364.D15F(Controls) ; port Angle_RF
ISC_SQ_363_1: C349.SHV(Output1) C454.SHV(PZT1)
ISC_SQ_363_2: C454.SHV(PZT1) C456.SHV/RA(HV)
ISC_SQ_364_1: C349.SHV(Output4) C455.SHV(PZT1)
ISC_SQ_364_2: C455.SHV(PZT1) C457.SHV(HV)
ISC_SQ_365: C216.TNC(Slow) C259.BNC(Temp)
ISC_SQ_366_1: C218.SHV(PZT) C259.BNC/RA(PZT)
ISC_SQ_366_2: C216.SHV(Fast) C218.SHV(PZT) ; port ISC_SQ_366
ISC_SQ_367_1: C216.SHV(EOM) ; port ISC_SQ_367
ISC_SQ_370: C219.N(Out_(HiPwr)_Mon) ; port ISC_SQ_370
ISC_SQ_373: C453.D15F(TEC) C456.D15M(TEC)
ISC_SQ_374_1: C455.SHV(PZT2) C458.SHV(HV)
ISC_SQ_374_2: C349.SHV(Output2) C454.SHV(PZT2)
ISC_SQ_375_1: C217#1.TNC(Fiber_Mon_2) ; port LASER FIBER MON
ISC_SQ_383_1: C217#1.TNC(Fiber_Mon_1) ; port PSL FIBER MON
ISC_SQ_391: C259.D37F(Laserhead) C259.D37M(Laserhead) ; port LaserHead
ISC_SQ_406: C356.TNC(2d) ; port ISC_SQ_406
ISC_SQ_430_2: C366.N(REF_(10dBm)) ; port ISC_SQ_430_2
ISC_SQ_472: C263.TNC ; port ISC_SQ_472
ISC_SQ_473: C264.TNC ; port ISC_SQ_473
ISC_SQ_474: C265.TNC ; port ISC_SQ_474
ISC_SQ_475: C266.TNC ; port ISC_SQ_475
ISC_SQ_507: C364.SMA(RFOut1) ; port ISC_SQ_507
ISC_SQ_513: C354.TNC(1c) ; port ISC_SQ_513
ISC_SQ_514: C354.TNC(1a) ; port ISC_SQ_514
ISC_SQ_516: C366.N(Out2_(13dBm)) ; port ISC_SQ_516
ISC_SQ_536: C349.TNC(IN_CH2) ; port ISC_SQ_536
ISC_SQ_547: C291.SHV(HV) C454.SHV(PZT2)
ISC_SQ_548: C217#1.TNC(PD_DC) ; port FIBR_DC
ISC_SQ_549: C356.TNC(2c) ; port ISC_SQ_549
ISC_SQ_552: C356.TNC(2b) ; port ISC_SQ_552
NetC263_TNC: C263.TNC C364.TNC(I-1)
NetC264_TNC: C264.TNC C364.TNC(Q-1)
NetC265_TNC: C265.TNC C364.TNC(I-2)
NetC266_TNC: C266.TNC C364.TNC(Q-2)
NetC357_M8: C357.M8(DC±15) C358.M8(DC+/-15)
NetC357_SMA: C357.SMA(RF_Out) C358.SMA(IN)

Not connected (* = marked no-connect by the designer): C208 Conec-3(DC+/-18)* D25F(From_DCPD)* D25M(To_Whitening)* TNC(Head_1_Output)*; C216 BNC(FastEXC)* Conec 3(+/-200V)*; C217#1 BNC(PD_Mon)* Conec 3(+/-18V)*; C218 TNC(RFPD)*; C219 Conec 3(+18V)*; C346 Conec-3(DC+15)*; C347 BNC(I-Mon1)* Conec-3(DC+/-18)*; C348 Conec-3(DC+/-18)* LEMO-2P(In2)*; C349 BNC(IN_CH1)* Conec-3(DC+/-17)*; C353 Conec-3(DC+/-18)* LEMO-2P(In2)*; C354 LEMO 2P(1a)*; C356 LEMO 2P(1a)*; C364 BNC(I-Mon1)* Conec-3(DC+/-18)*; C365 Conec-3(DC+/-18)*; C366 BNC(Tune)* Conec-3(DC+/-17)*; C367 BNC(M1)* Conec-3(DC+/-17)*

### Layout directives
Length: 8": ISC_SQ_200, ISC_SQ_201
Length: ft: ISC_SQ_202_1, ISC_SQ_204_1, ISC_SQ_205_1, ISC_SQ_206_1, ISC_SQ_217_1, ISC_SQ_218_1, ISC_SQ_219_1, ISC_SQ_220_1
Length: 92": ISC_SQ_203_1
Length: 35ft: ISC_SQ_203_2, ISC_SQ_212, ISC_SQ_363_1, ISC_SQ_364_1, ISC_SQ_374_2, ISC_SQ_548
Length: 48ft: ISC_SQ_202_2, ISC_SQ_217_2
Length: 5ft: ISC_SQ_207_1, ISC_SQ_221_1
Length: 16": ISC_SQ_208, ISC_SQ_213_2, ISC_SQ_231
Length: 20": ISC_SQ_209, ISC_SQ_232
Length: 40": ISC_SQ_233, ISC_SQ_234
Length: 10": ISC_SQ_211
Length: 60": ISC_SQ_210
Length: 18": ISC_SQ_202_3, ISC_SQ_203_3, ISC_SQ_217_3
Length: 12": ISC_SQ_91, ISC_SQ_94, ISC_SQ_95, ISC_SQ_97, ISC_SQ_341
Length: 36": ISC_SQ_96, ISC_SQ_98, ISC_SQ_99
Length: 6": ISC_SQ_298
Length: 126": ISC_SQ_364_2
Length: 171": ISC_SQ_374_1
Length: 10ft: ISC_SQ_373, ISC_SQ_406
Length: 81": ISC_SQ_363_2
Length: 129": (no net found under the mark)
Length: 48": ISC_SQ_365
Length: 24": ISC_SQ_366_2
Length: 57": (no net found under the mark)
Length: 4ft: ISC_SQ_391
Length: 9ft: ISC_SQ_275
Length: 50ft: ISC_SQ_106
Length: 12ft: ISC_SQ_513, ISC_SQ_514, ISC_SQ_549
Length: 84": ISC_SQ_547
Length: 328ft: FIBR_SQ_001
Length: 1ft: FIBR_SQ_018
Length: 2ft: FIBR_SQ_017
Length: 13ft: ISC_SQ_552

### Notes on the sheet
- 24.1MHz
- 80MHz
- SQZ SHG TEC
- SHG PZT
- (near C350) 80MHz, OPO
- (near C348) OPO Control
- CLF/LO PZT's
- Seed PZT
- LSC_DAC0_2
- Broadband PD Used
  Tee off DC and cable
  to pins 1/6 of DB9
- (near C351) SQZ RFPD OPO
- (near C357) 24.1MHz, SHG
- (near C353) SHG Control
- ADF error
- Fibr DC
- PMC Refl
- (near C359) SQZ SHG BBPD
- (near C364) 3.125MHz
- OMC
- 71MHz
- (near C365) SQZ Angle Control (aka LO)
- (near C366) OPO 79.2MHz
- (near C361) 3.125MHz, HDPD
- SQZ Homodyne
- (near C218) SQZ Laser Locking
- Key
- Dot Identifies Cable Shield Terminating to Backshell
- Pin With Triangle Indicates Pin on Rear or the Like
- Pin With No Triangle Indicates Pin on Front or the Like
- Light Blue Symbols Are In-Vacuum
- Yellow Symbols Are In-Air

### Library data of the parts
C208 = 3.125MHz OMC/Homodyne Breakout: Serial: Sxxxxxxx; System: ISC
C216 = 4G TTFSS: Serial: Sxxxxxxx; System: ISC
C217#1 = Laser Locking Fiber Beat Note: Serial: Sxxxxxxx; System: ISC
C217#2 = New Focus 1611: Serial: Sxxxxxxx; System: ISC
C218 = Patch Panel Laser Locking: Patch Panel (D1700144); Serial: Sxxxxxxx; System: ISC; Rack: SQZT0-Left; Slot: U36
C219 = 4G TTFSS Preamp: Serial: Sxxxxxxx; System: ISC
C259 = Mephisto 1000NE: Serial: Sxxxxxxx; System: ISC
C263-C266 = TNC Tee: Tee (TNC); Serial: Sxxxxxxx; System: ISC; Rack: SQZ-R1; Slot: U18
C291 C457 C458 = PZT: Serial: Sxxxxxxx; System: ISC
C296 = Fiber Port Thorlabs PAF Series: Serial: Sxxxxxxx; System: ISC
C346 = DelayLinePhaseShifter: Serial: Sxxxxxxx; System: ISC
C347 C364 = 2-Chan Demod: Serial: Sxxxxxxx; System: ISC
C348 C353 C365 = CommonModeBoard: Serial: Sxxxxxxx; System: ISC
C349 = PZT Driver (X4): Serial: Sxxxxxxx; System: ISC
C350 = LSC Head: Serial: Sxxxxxxx; System: ISC
C351 = Patch Panel Dual Frequency LSC RFPD: Patch Panel (D1200811); Serial: Sxxxxxxx; System: ISC; Rack: SQZT7-RightTop; Slot: U15
C352 = Patch Panel TNC 1U: Patch Panel (D1201470); Serial: Sxxxxxxx; System: ISC; Rack: SQZ-R1; Slot: U19
C354 C356 = Dual Dsub PatchPanel: Serial: Sxxxxxxx; System: ISC
C357 = BBPD: Serial: Sxxxxxxx; System: ISC
C358 = RF Preamplifier: Low Noise RF Preamplifier; Serial: Sxxxxxxx; System: ISC
C359 = Patch Panel Broadband PD: Patch Panel (D1200889); Serial: Sxxxxxxx; System: ISC; Rack: SQZT0-Left; Slot: U35
C361 = Homodyne Detector: Serial: Sxxxxxxx; System: ISC; Slot: On Table
C362 = Patch Panel Homodyne: Patch Panel (D1700149); Serial: Sxxxxxxx; System: ISC; Rack: SQZT7-RightTop; Slot: U6
C366 = VCO: Serial: Sxxxxxxx; System: ISC
C367 = X2 Freq. Mult.: Serial: Sxxxxxxx; System: ISC
C453 = Patch Panel TEC Driver: Patch Panel (D1201483); Serial: Sxxxxxxx; System: ISC
C454 C455 = Patch Panel PZT: Patch Panel (D1700146); Serial: Sxxxxxxx; System: ISC
C456 = SHG: Serial: Sxxxxxxx; System: ISC

## Sheet SqueezerRfControls2.SchDoc: Squeezer RF Controls
size C; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 33; SheetTotal: 37; DrawnBy: R.  Abbott; Engineer: R.  Abbott

### Parts
(Parts that share a designator on the sheet are numbered #1, #2 ... from top to bottom, then left to right.)
C197  LSC Demod Concentrator  DCC: D1100691  Rack: SQZ-R2  Slot: U4
C200  LSC RFPD Interface  DCC: D1102079  Rack: SQZ-R2  Slot: U5
C220  Common Mode Board  DCC: D0901781  Rack: SQZ-R1  Slot: U34
C221  VCO  DCC: D2100570  Rack: SQZ-R2  Slot: U30
C230  LSC Head  DCC: D1101176  Rack: SQZT7  Slot: FC_REFL
C231  Patch Panel Dual Frequency LSC RFPD  (value not drawn)  (parts A,B,C,D,E of 5)
C233  RLF 200.105MHz VCXO  DCC: D1600500  Rack: SQZ-R2  Slot: U21
C234  ADF 203.125MHz VCXO  DCC: D1600500  Rack: SQZ-R2  Slot: U23
C254  Patch Panel Dual Frequency LSC RFPD  (value not drawn)  (parts A,B,C,D,E of 5)
C260  Squeezer PLL Integration  DCC: D1900514  Rack: SQZ-R2  Slot: U25
C272  Delay Line Phase Shifter  DCC: D0900128  Rack: SQZ-R1  Slot: U32
C278  Thorlabs PDA100A  DCC: T1700460  Rack: SQZT7  Slot: GR_BEAT
C279  Tee  (value not drawn)
C287  2-Chan Demodulator  DCC: D1000181  Rack: SQZ-R1  Slot: U13
C288  Common Mode Board  DCC: D0901781  Rack: SQZ-R1  Slot: U11
C289  LSC iLIGO Head  DCC: D980454  Rack: SQZT0  Slot: PMC_REFL
C290  DCC: D1100433  Rack: SQZT0-Left  Slot: U17  (hidden comment: Patch Panel Legacy iLIGO LSC RFPD)  (parts A,B,C of 3)
C299  Patch Panel TNC 1U  (value not drawn)  (parts A,C of 4)
C372  Delay Line Phase Shifter  DCC: D0900128  Rack: SQZ-R1  Slot: U31
C373  Delay Line Phase Shifter  DCC: D0900128  Rack: SQZ-R1  Slot: U30
C374  LSC Head  DCC: D1101176  Rack: SQZT7  Slot: CLF_REFL
C375  Patch Panel Dual Frequency LSC RFPD  (value not drawn)  (parts A,B,C,D,E of 5)
C376  Patch Panel TNC 1U  (value not drawn)  (parts A,B,C,D of 4)
C377  2-Chan Demodulator  DCC: D1000181  Rack: SQZ-R1  Slot: U29
C379  Common Mode Board  DCC: D0901781  Rack: SQZ-R1  Slot: U27
C380  CLF VCXO  DCC: D1600500  Rack: SQZ-R2  Slot: U33
C?#1  Patch Panel TNC 1U  (value not drawn)  (part D of 4)
C?#2  Patch Panel TNC 1U  (value not drawn)  (part B of 4)

### Ports
Angle_RF (see SqueezerRfControls1[3C]), BEAT_DC (see SqueezerConcentrators[1C]), BEAT_PWR (see SqueezerConcentrators[5D]), CLF_CM_EXE (see SqueezerRfControls1[5B]), CLF_DC (see SqueezerConcentrators[5D]), CLF_RF (see SqueezerRfControls2[3B]), CLF_RF (see SqueezerRfControls2[6D]), CM_CLF_A (see SqueezerBeckhoff2[3B]), CM_CLF_B (see SqueezerBeckhoff2[3B]), CM_FC_A (see SqueezerBeckhoff2[3C]), CM_FC_B (see SqueezerBeckhoff2[3C]), CM_PMC_A (see SqueezerBeckhoff2[3D]), CM_PMC_B (see SqueezerBeckhoff2[3D]), Delay FC (see SqueezerBeckhoff2[3D]), Delay PMC (see SqueezerBeckhoff2[3D]), Delay_CLF1 (see SqueezerBeckhoff2[3B]), Delay_CLF2 (see SqueezerBeckhoff2[3B]), Delay_CLF3 (see SqueezerBeckhoff2[3B]), Delay_CLF4 (see SqueezerBeckhoff2[3B]), FC_DC (see SqueezerConcentrators[1C]), ISC_SQ_25_2 (see SqueezerRfDistribution[2A]), ISC_SQ_229 (see SqueezerRfDistribution[3C]), ISC_SQ_291 (see ISC_C1_SH2[4A]), ISC_SQ_294 (see ISC_C1_SH2[1C]), ISC_SQ_296 (see ISC_C1_SH2[1C]), ISC_SQ_326 (see SqueezerRfDistribution[4C]), ISC_SQ_353 (see SqueezerRfDistribution[4C]), ISC_SQ_354 (see ISC_C2_SH2[4B]), ISC_SQ_406 (see SqueezerRfControls1[5B]), ISC_SQ_424 (see SqueezerRfDistribution[4A]), ISC_SQ_432_2 (see SqueezerRfDistribution[2A]), ISC_SQ_437 (see SqueezerRfDistribution[3D]), ISC_SQ_438 (see SqueezerRfDistribution[3B]), ISC_SQ_439 (see SqueezerRfDistribution[4C]), ISC_SQ_451 (see SqueezerRfDistribution[5A]), ISC_SQ_452 (see SqueezerRfDistribution[5A]), ISC_SQ_455 (see SqueezerRfDistribution[5A]), ISC_SQ_478 (see SqueezerWfsWiring[5B]), ISC_SQ_503 (see ISC_C1_SH2[1C]), ISC_SQ_510 (see SqueezerRfDistribution[3C]), ISC_SQ_513 (see SqueezerRfControls1[4B]), ISC_SQ_514 (see SqueezerRfControls1[4B]), ISC_SQ_517 (see SqueezerRfDistribution[5A]), ISC_SQ_531 (see SqueezerRfDistribution[2A]), ISC_SQ_534 (see SqueezerRfControls2[2B]), ISC_SQ_534 (see SqueezerRfControls2[2C]), ISC_SQ_536 (see SqueezerRfControls1[4A]), ISC_SQ_537 (see ISC_C1_SH2[1C]), ISC_SQ_539 (see ISC_C1_SH2[1C]), OPO_LSC_Head_DC (see SqueezerRfControls1[1B]), PLL Int (see SqueezerBeckhoff2[3C]), PMC_DC (see SqueezerConcentrators[2D]), PMC_RF (see SqueezerRfControls2[3D]), PMC_RF (see SqueezerRfControls2[6D]), SHG/OPO_RF (see SqueezerRfControls1[3B]), Ties to Beckhoff, Ties to RF Distribution, VCO_SQZ_FC (see SqueezerBeckhoff2[3C]), VCXO_ADF (see SqueezerBeckhoff2[3C]), VCXO_CLF (see SqueezerBeckhoff2[3A]), VCXO_RLF (see SqueezerBeckhoff2[3C])

### Nets
ISC_SQ_25_2: C373.TNC(Input1) ; port ISC_SQ_25_2
ISC_SQ_97: C379.BNC(A-Test1) ; port CLF_CM_EXE
ISC_SQ_207_2: C200.D9F(Head_2) ; port OPO_LSC_Head_DC
ISC_SQ_214: C372.TNC(Input1) C373.TNC(Output2)
ISC_SQ_215: C372.TNC(Output2) C377.TNC(LO1)
ISC_SQ_222_1: C374.SMA(RF_HI) C375.TNC(RFLO)
ISC_SQ_222_2: C375.TNC(RFHI) C376.TNC
ISC_SQ_222_3: C376.TNC C377.SMA(RFOut1)
ISC_SQ_223_1: C374.SMA(Test_In) C375.TNC(TestIn)
ISC_SQ_224_1: C374.SMA(Test_Out) C375.TNC(TestOut)
ISC_SQ_225_1: C374.D9M(Controls) C375.D9F(Power)
ISC_SQ_225_2: C200.D9F(Head_1) C375.D9M(Power)
ISC_SQ_226: C373.TNC(Input2) C373.TNC_(Output1)
ISC_SQ_227: C377.TNC(I-1) C379.TNC(IN1)
ISC_SQ_228: C379.TNC(FastServo) C380.TNC(Tune)
ISC_SQ_229: C380.N(OUT(13dBm)) ; port ISC_SQ_229
ISC_SQ_254: C374.BNC(DC) ; port CLF_DC
ISC_SQ_291: C379.D9F(DAQ) ; port ISC_SQ_291
ISC_SQ_294: C377.D9F(DAQ) ; port ISC_SQ_294
ISC_SQ_296: C200.D9F(AN_OUT_To_AA) ; port ISC_SQ_296
ISC_SQ_312: C380.D25F(Controls) ; port VCXO_CLF
ISC_SQ_315: C372.D25M(Controls1) ; port Delay_CLF2
ISC_SQ_316: C372.D25M(Controls2) ; port Delay_CLF3
ISC_SQ_317: C379.D37F(Controls1) ; port CM_CLF_A
ISC_SQ_318: C379.D37F(Controls2) ; port CM_CLF_B
ISC_SQ_319: C373.D25M(Controls1) ; port Delay_CLF1
ISC_SQ_320: C373.D25M(Controls2) ; port Delay_CLF4
ISC_SQ_326: C380.N(Pmon1) ; port ISC_SQ_326
ISC_SQ_353: C233.N(Pmon1) ; port ISC_SQ_353
ISC_SQ_354: C197.D37F(CTRL) ; port ISC_SQ_354
ISC_SQ_358: C197.D15M(Demod_RF_Levels_2) ; port SHG/OPO_RF
ISC_SQ_359: C197.D15M(Demod_RF_Levels_3) ; port Angle_RF
ISC_SQ_360: C197.D15M(Demod_RF_Levels_4) C377.D15F(Controls) ; port CLF_RF
ISC_SQ_406: C260.TNC(Audio_Mon) ; port ISC_SQ_406
ISC_SQ_415: C372.TNC(Input2) C372.TNC_(Output1)
ISC_SQ_416: C377.TNC(Q-1) C379.TNC(IN2)
ISC_SQ_424: C260.N(200MHz_In_(10dBm)) ; port ISC_SQ_424
ISC_SQ_432_2: C272.TNC(Input2) ; port ISC_SQ_432_2
ISC_SQ_432_3: C272.TNC(Output2) C377.TNC(LO2)
ISC_SQ_437: C260.N(AOM3_Out_(13dBm)) ; port ISC_SQ_437
ISC_SQ_438: C260.N(3.125MHz_In_(10dBm)) ; port ISC_SQ_438
ISC_SQ_439: C234.N(Pmon1) ; port ISC_SQ_439
ISC_SQ_442_1: C230.SMA(RF_HI) C231.TNC(RFHI)
ISC_SQ_442_2: C231.TNC(RFHI) C376.TNC
ISC_SQ_442_3: C376.TNC C377.SMA(RFIn2)
ISC_SQ_443_1: C230.SMA(Test_In) C231.TNC(TestIn)
ISC_SQ_444_1: C230.SMA(Test_Out) C231.TNC(TestOut)
ISC_SQ_445_1: C230.BNC(DC) C231.TNC(RFLO)
ISC_SQ_445_2: C231.TNC(RFLO) ; port FC_DC
ISC_SQ_446_2: C230.D9M(Controls) C231.D9F(Power)
ISC_SQ_446_3: C200.D9F(Head_3) C231.D9M(Power)
ISC_SQ_447_1: C278.BNC(DC) C279.TNC
ISC_SQ_447_2: C254.TNC(RFHI) ; port BEAT_DC
ISC_SQ_448: C278.M8(DC±12) ; port BEAT_PWR
ISC_SQ_449: C254.D9F(Power) C279.TNC
ISC_SQ_450: C200.D9F(Head_4) C254.D9M(Power)
ISC_SQ_451: C233.N(Pmon2) ; port ISC_SQ_451
ISC_SQ_452: C234.N(Pmon2) ; port ISC_SQ_452
ISC_SQ_453: C233.N(OUT(13dBm)) C260.N(200.105MHz_VCXO_In_(10dBm))
ISC_SQ_454: C234.N(OUT(13dBm)) C260.N(203.125MHz_VCXO_In_(10dBm))
ISC_SQ_455: C221.N(Out2_(13dBm)) ; port ISC_SQ_455
ISC_SQ_456: C220.LEMO-2P(In2) C221.Lemo_2P(Tune)
ISC_SQ_478: C260.D9F(105kHz_Out) ; port ISC_SQ_478
ISC_SQ_485: C234.D25F(Controls) ; port VCXO_ADF
ISC_SQ_486: C233.D25F(Controls) ; port VCXO_RLF
ISC_SQ_490: C220.D37F(Controls1) ; port CM_FC_A
ISC_SQ_491: C220.D37F(Controls2) ; port CM_FC_B
ISC_SQ_492: C221.D25F(Controls) ; port VCO_SQZ_FC
ISC_SQ_497: C260.D25F(Controls) ; port PLL Int
ISC_SQ_498: C272.D25M(Controls2) ; port Delay FC
ISC_SQ_503: C220.D9F(DAQ) ; port ISC_SQ_503
ISC_SQ_510: C221.N(Out1_(13dBm)) ; port ISC_SQ_510
ISC_SQ_513: C234.TNC(Tune) ; port ISC_SQ_513
ISC_SQ_514: C233.TNC(Tune) ; port ISC_SQ_514
ISC_SQ_515: C220.TNC(IN1) C377.TNC(I-2)
ISC_SQ_517: C380.N(Pmon2) ; port ISC_SQ_517
ISC_SQ_531: C272.TNC(Input1) ; port ISC_SQ_531
ISC_SQ_534: C272.TNC_(Output1) C287.TNC(LO1) ; port ISC_SQ_534
ISC_SQ_535: C287.TNC(I-1) C288.TNC(IN1)
ISC_SQ_536: C288.TNC(Slow-Out1) ; port ISC_SQ_536
ISC_SQ_537: C287.D9F(DAQ) ; port ISC_SQ_537
ISC_SQ_538: C197.D15M(Demod_RF_Levels_1) C287.D15F(Controls) ; port PMC_RF
ISC_SQ_539: C288.D9F(DAQ) ; port ISC_SQ_539
ISC_SQ_540: C288.D37F(Controls1) ; port CM_PMC_A
ISC_SQ_541: C288.D37F(Controls2) ; port CM_PMC_B
ISC_SQ_542: C272.D25M(Controls1) ; port Delay PMC
ISC_SQ_544_1: C289.SMA(RF) C290.TNC(RFHI)
ISC_SQ_544_2: C290.TNC(RFHI) C299.TNC
ISC_SQ_544_3: C287.SMA(RFOut1) C299.TNC
ISC_SQ_545_1: C289.SMA(Test_In) C290.TNC(TestIn)
ISC_SQ_546_1: C289.D15M(Controls) C290.D15F(Power)
ISC_SQ_546_2: C290.D15M(Power) ; port PMC_DC
NetC254_TNC: C254.TNC(RFLO) C279.TNC

Not connected (* = marked no-connect by the designer): C197 D9M(Demod_IQ_Wh._1)*; C200 Conec-3(DC+/-18)*; C220 BNC(A-Test1)* Conec-3(DC+/-18)*; C221 BNC(Tune)* Conec-3(DC+/-17)*; C233 BNC(M1)* Conec-3(DC+/-17)*; C234 BNC(M1)* Conec-3(DC+/-17)*; C260 BNC(M1)* Conec-3(DC+/-17)*; C272 Conec-3(DC+15)*; C287 BNC(I-Mon1)* Conec-3(DC+/-18)*; C288 BNC(A-Test1)* Conec-3(DC+/-18)* LEMO-2P(In2)*; C289 LEMO(DC)*; C372 Conec-3(DC+15)*; C373 Conec-3(DC+15)*; C377 BNC(I-Mon1)* Conec-3(DC+/-18)*; C379 Conec-3(DC+/-18)* LEMO-2P(In2)*; C380 BNC(M1)* Conec-3(DC+/-17)*; C?#1 TNC(4)*; C?#2 TNC(2)*

### Layout directives
Length: ": ISC_SQ_222_1, ISC_SQ_223_1, ISC_SQ_224_1, ISC_SQ_225_1
Length: 48ft: ISC_SQ_207_2, ISC_SQ_222_2, ISC_SQ_225_2
Length: 16": ISC_SQ_227, ISC_SQ_416
Length: 88": ISC_SQ_228
Length: 35ft: ISC_SQ_229, ISC_SQ_510, ISC_SQ_544_2
Length: 10": ISC_SQ_214
Length: 4": ISC_SQ_226, ISC_SQ_415
Length: 18": ISC_SQ_222_3, ISC_SQ_442_3, ISC_SQ_544_3
Length: 12": ISC_SQ_215, ISC_SQ_432_3
Length: 90": ISC_SQ_442_1, ISC_SQ_443_1, ISC_SQ_444_1, ISC_SQ_445_1, ISC_SQ_446_2, ISC_SQ_447_1
Length: 38ft: ISC_SQ_442_2, ISC_SQ_445_2, ISC_SQ_446_3, ISC_SQ_447_2, ISC_SQ_450
Length: ft: ISC_SQ_296
Length: 8ft: ISC_SQ_456
Length: 36": ISC_SQ_453, ISC_SQ_454, ISC_SQ_515
Length: 15ft: ISC_SQ_358, ISC_SQ_359, ISC_SQ_360, ISC_SQ_478, ISC_SQ_538
Length: 24": ISC_SQ_437, ISC_SQ_536
Length: 5ft: ISC_SQ_544_1, ISC_SQ_545_1, ISC_SQ_546_1
Length: 60": ISC_SQ_534
Length: 20": ISC_SQ_535

### Notes on the sheet
- 200MHz
- 3.125MHz
- 200.105MHz
- 203.125MHz
- 6.25MHz
- 40MHz
- 35.5MHz
- (near C375) SQZ RFPD CLF
- (near C374) 6.25MHz, CLF
- LSC_ADC3_CLF
- (near C379) CLF Control
- (near C230) 40MHz, FC green
- (near C220) Green FC Control
- (near C221) Green FC Locking
- (near C278) 1MHz, Beat green
- (near C231) SQZ RFPD FC Green
- Thorlabs PDA100A2 Used
  Tee off DC, RF HI and cable
  to pins 1/6 of DB9
- (near C254) SQZ RFPD Beat Green
- (near C289) 35.5MHz, PMC REFL
- (near C288) PMC Control
- (near C290) SQZ RFPD PMC
- Key
- Dot Identifies Cable Shield Terminating to Backshell
- Pin With Triangle Indicates Pin on Rear or the Like
- Pin With No Triangle Indicates Pin on Front or the Like
- Light Blue Symbols Are In-Vacuum
- Yellow Symbols Are In-Air

### Library data of the parts
C197 = LSC Demod Concentrator: Serial: Sxxxxxxx; System: ISC
C200 = LSC RFPD Interface: Serial: Sxxxxxxx; System: ISC
C220 C288 C379 = CommonModeBoard: Serial: Sxxxxxxx; System: ISC
C221 = VCONew: New VCO; Serial: Sxxxxxxx; System: ISC
C230 C374 = LSC Head: Serial: Sxxxxxxx; System: ISC
C231 = Patch Panel Dual Frequency LSC RFPD: Patch Panel (D1200811); Serial: Sxxxxxxx; System: ISC; Rack: SQZT7-RightTop; Slot: U19
C233 C234 C380 = VCXO: Serial: Sxxxxxxx; System: ISC
C254 = Patch Panel Dual Frequency LSC RFPD: Patch Panel (D1200811); Serial: Sxxxxxxx; System: ISC; Rack: SQZT7-RightTop; Slot: U23
C260 = Squeezer PLL: Serial: Sxxxxxxx; System: ISC
C272 C372 C373 = DelayLinePhaseShifter: Serial: Sxxxxxxx; System: ISC
C278 = Thorlabs PDA100A: Serial: Sxxxxxxx; System: ISC
C279 = TNC Tee: Tee (TNC); Serial: Sxxxxxxx; System: ISC; Rack: SQZT7; Slot: U?
C287 C377 = 2-Chan Demod: Serial: Sxxxxxxx; System: ISC
C289 = LSC Legacy Head: LSC iLIGO Legacy Head; Serial: Sxxxxxxx; System: ISC
C290 = Patch Panel Legacy LSC RFPD: Patch Panel (D1100433); Serial: Sxxxxxxx; System: ISC
C299 C?#1 C?#2 = Patch Panel TNC 1U: Patch Panel (D1201470); Serial: Sxxxxxxx; System: ISC; Rack: SQZ-R1; Slot: U12
C375 = Patch Panel Dual Frequency LSC RFPD: Patch Panel (D1200811); Serial: Sxxxxxxx; System: ISC; Rack: SQZT7-RightTop; Slot: U11
C376 = Patch Panel TNC 1U: Patch Panel (D1201470); Serial: Sxxxxxxx; System: ISC; Rack: SQZ-R1; Slot: U28