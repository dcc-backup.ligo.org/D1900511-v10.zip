# Altium project D1900511.PrjPcb (part 6 of 7)

## Sheet SqueezerConcentrators.SchDoc: Squeezer Concentrators
size C; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 34; SheetTotal: 37; DrawnBy: R.  Abbott; Engineer: R.  Abbott; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.09¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=7¦PrintQuality=-4¦MediaType=1¦DitherType=10¦PaperKind=11x17¦PrintScaleMode=1

### Parts
C202  RLF Nocth Filter  DCC: D2200393  Rack: SQZ-R2  Slot: U15
C235  DCPD  DCC: E1300310  Rack: SQZT0  Slot: FC Launch
C253  Aux. Conc. 1  DCC: D1102065  Rack: SQZ-R2  Slot: U9
C255  DCPD  DCC: E1300310  Rack: SQZT7  Slot: FC Refl Rejected
C256  DCPD  DCC: E1300310  Rack: SQZT7  Slot: GR Beat Rejected
C271  Tee  (value not drawn)
C273  SQZ Aux. Conc. 9  DCC: D2000505  Rack: SQZ-R2  Slot: U10
C275  Shutter Controller  DCC: D1102312  Rack: SQZT7-R1  Slot: U3
C283  Tee  (value not drawn)
C284  Tee  (value not drawn)
C295  SQZ Aux. Conc. 11  DCC: D2300326  Rack: SQZ-R2  Slot: U3
C297  Tee  (value not drawn)
C298  Thorlabs PDA100A  DCC: T1700460  Rack: SQZT0  Slot: PMC_TRANS
C315  Tee  (value not drawn)
C387  DCC: D1201399  Rack: SQZT0-Left  Slot: U25  (hidden comment: Patch Panel DCPD)  (parts A,B,C,D,E,F of 6)
C388  DCC: D1201399  Rack: SQZT0-Left  Slot: U28  (hidden comment: Patch Panel DCPD)  (parts A,B,C,D,E,F of 6)
C389  DCC: D1201399  Rack: SQZT7-RightTop  Slot: U27  (hidden comment: Patch Panel DCPD)  (parts A,B,C,D,E,F of 6)
C390  DCC: D1102369  Rack: SQZT7-RightBottom  Slot: U35  (hidden comment: Patch Panel Uniblitz Shutters)  (parts A,B of 2)
C391  DCPD  DCC: E1300310  Rack: SQZT0  Slot: Fiber Rejected
C392  DCPD  DCC: E1300310  Rack: SQZT0  Slot: CLF Launch
C393  DCPD  DCC: E1300310  Rack: SQZT0  Slot: CLF Rejected
C394  DCPD  DCC: E1300310  Rack: SQZT0  Slot: SHG Launch
C395  DCPD  DCC: E1300310  Rack: SQZT0  Slot: SHG Rejected
C396  DCPD  DCC: E1300310  Rack: SQZT0  Slot: Seed Launch
C397  DCPD  DCC: E1300310  Rack: SQZT0  Slot: LO Launch
C398  DCPD  DCC: E1300310  Rack: SQZT0  Slot: Fiber Trans
C399  Thorlabs PDA100A  DCC: T1700460  Rack: SQZT7  Slot: OPO_TRANS
C400  DCPD  DCC: E1300310  Rack: SQZT7  Slot: OPO Refl Rejected
C401  Uniblitz Shutter VS25  DCC: T1700461  Rack: SQZT7  Slot: CLF Beam
C402  SQZ Aux. Conc. 7  DCC: D1700176  Rack: SQZ-R2  Slot: U12
C403  ISC Whitening Chassis  DCC: D1002559  Rack: SQZ-R1  Slot: U13
C404  DCC: D1101072  Rack: SQZT0-Left  Slot: U23  (hidden comment: Patch Panel DCPD Interface)  (parts A,B of 2)
C405  DCC: D1101072  Rack: SQZT7-RightTop  Slot: U30  (hidden comment: Patch Panel DCPD Interface)  (parts A,B of 2)
C406  Generic PD Interface  DCC: D1002932  Rack: SQZT0  Slot: Cable Tray
C407  Generic PD Interface  DCC: D1002932  Rack: SQZT7  Slot: Cable Tray
C408  Thorlabs PDA100A  DCC: T1700460  Rack: SQZT0  Slot: LASER_IR
C409  Thorlabs PDA100A  DCC: T1700460  Rack: SQZT0  Slot: SHG_GR
C410  Thorlabs PDA100A  DCC: T1700460  Rack: SQZT7  Slot: CLF_TRIG
C411  Thorlabs PDA100A  DCC: T1700460  Rack: SQZT7  Slot: IR_PD
C459  SQZ Aux. Conc. 8  DCC: D1700179  Rack: SQZ-R2  Slot: U11
C467  Tee  (value not drawn)

### Ports
AUX SQZ (see SqueezerBeckhoff2[3B]), BEAT_DC (see SqueezerRfControls2[2B]), BEAT_PWR (see SqueezerRfControls2[1C]), CLF_DC (see SqueezerRfControls2[1B]), CLF_TRIG (see SqueezerConcentrators[4B]), CLF_TRIG (see SqueezerConcentrators[5D]), DCPD 1 (see SqueezerInVacControls[6C]), DCPD 2 (see SqueezerInVacControls[6C]), DCPD 3 (see SqueezerInVacControls[6C]), DCPD 4 (see SqueezerInVacControls[6C]), DCPD 5 (see SqueezerInVacControls[6C]), DCPD 7 (see SqueezerBeckhoff2[3B]), DCPD 8 (see SqueezerBeckhoff2[3B]), DCPD 9 (see SqueezerBeckhoff2[3B]), DCPD 11 (see SqueezerBeckhoff2[3D]), FC_DC (see SqueezerRfControls2[2B]), FIBR_DC (see SqueezerRfControls1[3D]), ISC_SQ_80 (see ISC_C2_SH1[1B]), ISC_SQ_81 (see ISC_C2_SH1[1B]), ISC_SQ_83 (see ISC_C1_SH1[4D]), ISC_SQ_84 (see ISC_C1_SH1[4D]), ISC_SQ_89 (see SqueezerConcentrators[2B]), ISC_SQ_89 (see SqueezerConcentrators[3C]), ISC_SQ_422 (see SqueezerRfDistribution[3D]), ISC_SQ_423 (see SqueezerRfDistribution[3D]), ISC_SQ_500 (see ISC_C1_SH2[1C]), ISC_SQ_525 (see SqueezerWfsWiring[3B]), ISC_SQ_528 (see SqueezerRfDistribution[4A]), ISC_SQ_549 (see SqueezerRfControls1[5B]), ISC_SQ_552 (see SqueezerRfControls1[5B]), LASER FIBER MON (see SqueezerRfControls1[2D]), OPO_DC (see SqueezerRfControls1[1A]), OPOT_PWR (see SqueezerConcentrators[4B]), OPOT_PWR (see SqueezerConcentrators[5D]), PMC_DC (see SqueezerRfControls2[2D]), PSL FIBER MON (see SqueezerRfControls1[2D]), SHG_DC (see SqueezerRfControls1[1B]), SHG_PWR (see SqueezerRfControls1[1B]), Shutter SQZT7 (see SqueezerBeckhoff2[1C]), Ties_to_Other_Sheets

### Nets
ISC_SQ_80: C403.D37F(BinaryReadback1) ; port ISC_SQ_80
ISC_SQ_81: C403.D37F(Bin.Cont.2) ; port ISC_SQ_81
ISC_SQ_82: C402.D25F(To_Whitening) C403.D25M(An.Sig.In)
ISC_SQ_83: C403.D9F(AnalogOut0-3) ; port ISC_SQ_83
ISC_SQ_84: C403.D9F(AnalogOut4-7) ; port ISC_SQ_84
ISC_SQ_88: C402.D9M(PDDC_1-4_IN) C404.D9F(Output)
ISC_SQ_89: C273.D9M(PDDC_1-4_IN) C405.D9F(Output) ; port ISC_SQ_89
ISC_SQ_246: C406.BNC(CH_2) ; port SHG_DC
ISC_SQ_247: C406.BNC(CH_3) C408.BNC/RA(DC)
ISC_SQ_248: C406.BNC(CH_4) C409.BNC(DC)
ISC_SQ_250: C406.M8(DC_+/-15V_Out2) ; port SHG_PWR
ISC_SQ_251: C406.M8(DC_+/-12V_Out3) C408.M8(DC±12)
ISC_SQ_252: C406.M8(DC_+/-12V_Out4) C409.M8(DC±12)
ISC_SQ_253: C271.BNC C410.BNC(DC)
ISC_SQ_254: C407.BNC(CH_3) ; port CLF_DC
ISC_SQ_255: C407.BNC(CH_4) ; port OPO_DC
ISC_SQ_256: C407.M8(DC_+/-12V_Out1) C410.M8(DC±12)
ISC_SQ_257_1: C275.TNC(PD_1) C389.TNC
ISC_SQ_257_2: C271.BNC C389.TNC ; port CLF_TRIG
ISC_SQ_258_1: C275.D9F(Shutter_1) C390.D9M(Output)
ISC_SQ_258_2: C390.D9F(Output) C401.P7M
ISC_SQ_323: C402.D37F(CTRL) ; port DCPD 7
ISC_SQ_324: C459.D37F(CTRL) ; port DCPD 8
ISC_SQ_361: C402.TNC(PD_Amp._(In)_PD5) ; port DCPD 1
ISC_SQ_362: C402.TNC(PD_Amp._(In)_PD6) ; port DCPD 2
ISC_SQ_375_1: C459.TNC(PD_Amp._(In)_PD1) ; port LASER FIBER MON
ISC_SQ_375_2: C387.TNC C391.BNC/RA(PD)
ISC_SQ_376_1: C387.TNC C459.TNC(PD_Amp._(In)_PD2)
ISC_SQ_376_2: C387.TNC C392.BNC/RA(PD)
ISC_SQ_377_1: C387.TNC C459.TNC(PD_Amp._(In)_PD3)
ISC_SQ_377_2: C387.TNC C393.BNC/RA(PD)
ISC_SQ_378_1: C387.TNC C459.TNC(PD_Amp._(In)_PD4)
ISC_SQ_378_2: C387.TNC C394.BNC/RA(PD)
ISC_SQ_379_1: C387.TNC C459.TNC(PD_Amp._(In)_PD5)
ISC_SQ_379_2: C387.TNC C395.BNC/RA(PD)
ISC_SQ_380_1: C387.TNC C459.TNC(PD_Amp._(In)_PD6)
ISC_SQ_380_2: C387.TNC C396.BNC/RA(PD)
ISC_SQ_381_1: C388.TNC C459.TNC(PD_Amp._(In)_PD7)
ISC_SQ_381_2: C388.TNC C397.BNC/RA(PD)
ISC_SQ_382_1: C388.TNC C459.TNC(PD_Amp._(In)_PD8)
ISC_SQ_382_2: C235.BNC/RA(PD) C388.TNC
ISC_SQ_383_1: C402.TNC(PD_Amp._(In)_PD3) ; port PSL FIBER MON
ISC_SQ_383_2: C388.TNC C398.BNC/RA(PD)
ISC_SQ_384_1: C283.TNC C389.TNC
ISC_SQ_384_2: C389.TNC C399.BNC(DC)
ISC_SQ_385_1: C389.TNC C402.TNC(PD_Amp._(In)_PD2)
ISC_SQ_385_2: C389.TNC C400.BNC/RA(PD)
ISC_SQ_386_1: C389.TNC C402.TNC(PD_Amp._(In)_PD4)
ISC_SQ_386_2: C255.BNC/RA(PD) C389.TNC
ISC_SQ_387: C404.D9M(Output) C406.D9F(Out)
ISC_SQ_388: C404.3W3(DC±17) C406.3W3(DC±18)
ISC_SQ_389: C405.D9M(Output) C407.D9F(Out)
ISC_SQ_390: C405.3W3(DC±17) C407.3W3(DC±18)
ISC_SQ_407: C399.M8(DC±12) C407.M8(DC_+/-12V_Out4) ; port OPOT_PWR
ISC_SQ_408: C407.BNC(CH_2) C411.BNC(DC)
ISC_SQ_409: C407.M8(DC_+/-12V_Out2) C411.M8(DC±12)
ISC_SQ_422: C202.TNC(In1) C273.TNC(PD_Mon_3)
ISC_SQ_422_2: C202.TNC(Out1) ; port ISC_SQ_422
ISC_SQ_423: C283.TNC ; port ISC_SQ_423
ISC_SQ_445_2: C253.TNC(Analog_Input_3) ; port FC_DC
ISC_SQ_447_2: C467.TNC ; port BEAT_DC
ISC_SQ_448: C407.M8(DC_+/-12V_Out3) ; port BEAT_PWR
ISC_SQ_458_1: C273.TNC(PD_Amp._(In)_PD1) C388.TNC
ISC_SQ_459_1: C273.TNC(PD_Amp._(In)_PD2) C389.TNC
ISC_SQ_459_2: C256.BNC/RA(PD) C389.TNC
ISC_SQ_460: C273.TNC(PD_Amp._(In)_PD3) C389.TNC
ISC_SQ_461: C273.TNC(PD_Amp._(In)_PD4) ; port DCPD 3
ISC_SQ_462: C273.TNC(PD_Amp._(In)_PD5) ; port DCPD 4
ISC_SQ_463: C273.TNC(PD_Amp._(In)_PD6) ; port DCPD 5
ISC_SQ_496: C275.D15F(Controls) ; port Shutter SQZT7
ISC_SQ_500: C273.D9F(PDDC_1-4_OUT) ; port ISC_SQ_500
ISC_SQ_501: C273.D37F(CTRL) ; port DCPD 9
ISC_SQ_509: C253.D37F(Controls) ; port AUX SQZ
ISC_SQ_525: C467.TNC ; port ISC_SQ_525
ISC_SQ_528: C284.TNC ; port ISC_SQ_528
ISC_SQ_543: C295.D37F(CTRL) ; port DCPD 11
ISC_SQ_546_2: C295.D15F(Legacy_RFPD) ; port PMC_DC
ISC_SQ_548: C297.TNC ; port FIBR_DC
ISC_SQ_549: C297.TNC ; port ISC_SQ_549
ISC_SQ_550: C298.M8(DC±12) C406.M8(DC_+/-12V_Out1)
ISC_SQ_551: C298.BNC(DC) C406.BNC(CH_1)
ISC_SQ_552: C315.TNC ; port ISC_SQ_552
NetC253_TNC: C253.TNC(Analog_Input_1) C297.TNC
NetC253_TNC: C253.TNC(Analog_Input_4) C284.TNC  [a separate net that carries the same name]
NetC271_BNC: C271.BNC C407.BNC(CH_1)
NetC283_TNC: C283.TNC C402.TNC(PD_Amp._(In)_PD1)
NetC284_TNC: C284.TNC C467.TNC
NetC295_TNC: C295.TNC(Mon_1) C315.TNC

Not connected (* = marked no-connect by the designer): C202 Conec-3(DC+/-17)*; C273 BNC(Mon_1)* Conec-3(+/-17VDC)* D25F(To_Whitening)*; C275 BNC(Open_1)* Conec-3(+24VDC)*; C295 Conec-3(+/-17VDC)*; C402 BNC(PD_Mon_1)* Conec-3(+/-17VDC)* D9F(PDDC_1-4_OUT)*; C403 Conec-3(DC+/-18)*; C459 BNC(Mon_1)* Conec-3(+/-17VDC)* D9F(OUT_1-4)* D25F(To_Whitening)*

### Layout directives
Length: 6ft: ISC_SQ_361, ISC_SQ_362, ISC_SQ_461, ISC_SQ_462, ISC_SQ_463
Length: 5ft: ISC_SQ_82, ISC_SQ_387, ISC_SQ_389
Length: 154": ISC_SQ_375_2
Length: 159": ISC_SQ_376_2, ISC_SQ_377_2
Length: 134": ISC_SQ_378_2
Length: 97": ISC_SQ_379_2
Length: 114": ISC_SQ_380_2
Length: 128": ISC_SQ_381_2
Length: 35ft: ISC_SQ_88, ISC_SQ_375_1, ISC_SQ_376_1, ISC_SQ_377_1, ISC_SQ_378_1, ISC_SQ_379_1, ISC_SQ_380_1, ISC_SQ_381_1, ISC_SQ_382_1, ISC_SQ_383_1, ISC_SQ_458_1, ISC_SQ_546_2
Length: 48ft: ISC_SQ_89, ISC_SQ_384_1, ISC_SQ_385_1, ISC_SQ_386_1
Length: ": ISC_SQ_257_2, ISC_SQ_258_2, ISC_SQ_382_2, ISC_SQ_384_2, ISC_SQ_385_2, ISC_SQ_386_2, ISC_SQ_459_2
Length: 135": ISC_SQ_383_2
Length: 41": ISC_SQ_388
Length: ?ft: ISC_SQ_253, ISC_SQ_254, ISC_SQ_255, ISC_SQ_256, ISC_SQ_390, ISC_SQ_407, ISC_SQ_408, ISC_SQ_409
Length: 40": ISC_SQ_550, ISC_SQ_551
Length: 53": ISC_SQ_246, ISC_SQ_250
Length: 139": ISC_SQ_247
Length: 69": ISC_SQ_248
Length: 133": ISC_SQ_251
Length: 63": ISC_SQ_252
Length: 0": NetC271_BNC
Length: 60": ISC_SQ_423
Length: 38ft: ISC_SQ_459_1, ISC_SQ_460
Length: 60'': ISC_SQ_422, ISC_SQ_422_2
Length: 24": ISC_SQ_257_1, ISC_SQ_258_1
Length: 4ft: ISC_SQ_448

### Notes on the sheet
- (near C398) Spare A
- DC PD
- FC_FIBR_Rejected (in-vac)
- OFI_A_Rejected (in-vac)
- OFI_B_Rejected (in-vac)
- (near C256) Spare B
- Shutter
- SHG_FIBR_Rejected (in-vac)
- (near C403) CLF_FIBR_Rejected (in-vac)
- Swap DCPD1 & DCPD2 for H1
- AS/SQZ DC PD Box
- DC PD Interface Box
- Key
- Dot Identifies Cable Shield Terminating to Backshell
- Pin With Triangle Indicates Pin on Rear or the Like
- Pin With No Triangle Indicates Pin on Front or the Like
- Light Blue Symbols Are In-Vacuum
- Yellow Symbols Are In-Air

### Library data of the parts
C202 = RLF Nocth Filter: Serial: Sxxxxxxx; System: ISC
C235 C255 C256 C391-C398 C400 = DCPD Unamplified: Unamplified DCPD; Serial: Sxxxxxxx; System: ISC
C253 = Aux. Conc. 1: Serial: Sxxxxxxx; System: ISC
C271 = TNC Tee: Tee (TNC); Serial: Sxxxxxxx; System: ISC; Rack: SQZT7
C273 = SQZ Aux. Conc. 9: Serial: Sxxxxxxx; System: ISC
C275 = Shutter Controller: Serial: Sxxxxxxx; System: ISC
C283 = TNC Tee: Tee (TNC); Serial: Sxxxxxxx; System: ISC; Rack: SQZ-R1; Slot: U18
C284 C297 C467 = TNC Tee: Tee (TNC); Serial: Sxxxxxxx; System: ISC; Rack: SQZ-R2; Slot: U9
C295 = SQZ Aux. Conc. 11: Serial: Sxxxxxxx; System: ISC
C298 C399 C408-C411 = Thorlabs PDA100A: Serial: Sxxxxxxx; System: ISC
C315 = TNC Tee: Tee (TNC); Serial: Sxxxxxxx; System: ISC; Rack: SQZ-R2; Slot: U3
C387-C389 = Patch Panel DCPD: Patch Panel (D1201399); Serial: Sxxxxxxx; System: ISC
C390 = Patch Panel Uniblitz Shutters: Patch Panel (D1102369); Serial: Sxxxxxxx; System: ISC
C401 = Uniblitz Shutter: Serial: Sxxxxxxx; System: ISC
C402 = SQZ Aux. Conc. 7: Serial: Sxxxxxxx; System: ISC
C403 = ISC Whitening: Serial: Sxxxxxxx
C404 C405 = Patch Panel DCPD Interface: Patch Panel (D1101072); Serial: Sxxxxxxx; System: ISC
C406 C407 = Generic PD Interface: Serial: Sxxxxxxx; System: ISC
C459 = SQZ Aux. Conc. 8: Serial: Sxxxxxxx; System: ISC

## Sheet SqueezerMiscellaneous.SchDoc: Squeezer Miscellaneous
size C; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 35; SheetTotal: 37; DrawnBy: R.  Abbott; Engineer: R.  Abbott; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.09¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=7¦PrintQuality=-4¦MediaType=1¦DitherType=10¦PaperKind=11x17¦PrintScaleMode=1

### Parts
C228  DCC: D1200813  Rack: SQZT7-RightBottom  Slot: U41  (hidden comment: Patch Panel GigE Camera)  (parts A,B of 2)
C236  Motorized Flipper MFF101  DCC: T1700462  Rack: SQZT0  Slot: MF5 FC Green
C237  Camera GigE  DCC: T1700295  Rack: SQZT7  Slot: FC REFL
C412  SQZ Concentrator Flipper  DCC: D1700171  Rack: SQZT0-R1  Slot: U3
C413  DCC: D1700169  Rack: SQZT0-Right  Slot: U10  (hidden comment: Patch Panel Motorized Flipper)  (parts A,B,C,D,E,F,G of 7)
C414  DCC: D1700169  Rack: SQZT0-Right  Slot: U14  (hidden comment: Patch Panel Motorized Flipper)  (parts A,B,C,D,E,F,G of 7)
C415  DCC: D1700169  Rack: SQZT7-RightTop  Slot: U38  (hidden comment: Patch Panel Motorized Flipper)  (parts A,B,C,D,E,F,G of 7)
C416  DCC: D1700326  Rack: SQZT0-Right  Slot: U8  (hidden comment: Patch Panel Optical Fiber Switch)
C417  DCC: D1200813  Rack: SQZT0-Right  Slot: U24  (hidden comment: Patch Panel GigE Camera)  (parts A,B of 2)
C418  DCC: D1200813  Rack: SQZT0-Right  Slot: U26  (hidden comment: Patch Panel GigE Camera)  (parts A,B of 2)
C419  DCC: D1200813  Rack: SQZT7-RightBottom  Slot: U39  (hidden comment: Patch Panel GigE Camera)  (parts A,B of 2)
C420  Motorized Flipper MFF101  DCC: T1700462  Rack: SQZT0  Slot: MF1 Green Pump
C421  Motorized Flipper MFF101  DCC: T1700462  Rack: SQZT7  Slot: MF2 Homodyne
C422  Motorized Flipper MFF101  DCC: T1700462  Rack: SQZT0  Slot: MF3 CLF
C423  Motorized Flipper MFF101  DCC: T1700462  Rack: SQZT0  Slot: MF4 Seed
C424  Motorized Flipper MFF101  DCC: T1700462  Rack: SQZT7  Slot: Homodyne Path
C425  Optical Fiber Switch  DCC: C1700200  Rack: SQZT0  Slot: CLF/Seed Switch
C426  Camera GigE  DCC: T1700295  Rack: SQZT0  Slot: SHG Trans
C427  Camera GigE  DCC: T1700295  Rack: SQZT7  Slot: OPO Trans
C428  Camera GigE  DCC: T1700295  Rack: SQZT7  Slot: IR Trans

### Ports
Flipper (see SqueezerBeckhoff2[3B]), LaserNE (see SqueezerRfControls1[6D]), Ties to Other Sheets

### Nets
ISC_SQ_259_1: C412.TNC(OUT_1) C413.TNC(ControlA)
ISC_SQ_259_2: C413.TNC(ControlA) C420.SMA/RA(Trig_A)
ISC_SQ_260_1: C412.TNC(IN_1) C413.TNC(StateA)
ISC_SQ_260_2: C413.TNC(StateA) C420.SMA/RA(Trig_B)
ISC_SQ_261_1: C412.TNC(OUT_2) C415.TNC(ControlB)
ISC_SQ_261_2: C415.TNC(ControlB) C421.SMA/RA(Trig_A)
ISC_SQ_262_1: C412.TNC(IN_2) C415.TNC(StateB)
ISC_SQ_262_2: C415.TNC(StateB) C421.SMA/RA(Trig_B)
ISC_SQ_263_1: C412.TNC(OUT_3) C413.TNC(ControlC)
ISC_SQ_263_2: C413.TNC(ControlC) C422.SMA/RA(Trig_A)
ISC_SQ_264_1: C412.TNC(IN_3) C413.TNC(StateC)
ISC_SQ_264_2: C413.TNC(StateC) C422.SMA/RA(Trig_B)
ISC_SQ_265_1: C412.TNC(OUT_4) C414.TNC(ControlA)
ISC_SQ_265_2: C414.TNC(ControlA) C423.SMA/RA(Trig_A)
ISC_SQ_266_1: C412.TNC(IN_4) C414.TNC(StateA)
ISC_SQ_266_2: C414.TNC(StateA) C423.SMA/RA(Trig_B)
ISC_SQ_267_1: C412.TNC(OUT_5) C414.TNC(ControlB)
ISC_SQ_267_2: C236.SMA/RA(Trig_A) C414.TNC(ControlB)
ISC_SQ_268_1: C412.TNC(IN_5) C414.TNC(StateB)
ISC_SQ_268_2: C236.SMA/RA(Trig_B) C414.TNC(StateB)
ISC_SQ_269_1: C412.TNC(OUT_6) C415.TNC(ControlA)
ISC_SQ_269_2: C415.TNC(ControlA) C424.SMA/RA(Trig_A)
ISC_SQ_270_1: C412.TNC(IN_6) C415.TNC(StateA)
ISC_SQ_270_2: C415.TNC(StateA) C424.SMA/RA(Trig_B)
ISC_SQ_271: C413.1.35/3.5(Barrel2) C420.1.35/3.5mm(DC15)
ISC_SQ_272: C415.1.35/3.5(Barrel2) C421.1.35/3.5mm(DC15)
ISC_SQ_273: C413.1.35/3.5(Barrel3) C422.1.35/3.5mm(DC15)
ISC_SQ_274: C414.1.35/3.5(Barrel1) C423.1.35/3.5mm(DC15)
ISC_SQ_275: C412.M12(Laser_NE_Relay_1) ; port LaserNE
ISC_SQ_276: C412.TNC(OUT_8) C416.TNC(In)
ISC_SQ_277: C412.TNC(IN_8) C416.TNC(Out)
ISC_SQ_278: C412.M12(Laser_NE_Relay_2) C416.M12(Relay)
ISC_SQ_279: C416.M12(Switch) C425.Molex-KK2695-5(OFS)
ISC_SQ_280: C417.RJ-45 C426.RJ-45(GigE)
ISC_SQ_281: C419.RJ-45 C427.RJ-45(GigE)
ISC_SQ_282: C419.RF-45 C428.RJ-45(GigE)
ISC_SQ_322: C412.D25F(CTRL) ; port Flipper
ISC_SQ_410: C415.1.35/3.5(Barrel1) C424.1.35/3.5mm(DC15)
ISC_SQ_464: C236.1.35/3.5mm(DC15) C414.1.35/3.5(Barrel2)
ISC_SQ_465: C228.RJ-45 C237.RJ-45(GigE)

Not connected (* = marked no-connect by the designer): C228 RF-45(2)*; C412 Conec-2(+24VDC)*; C413 D2V2S(Power)*; C414 D2V2S(Power)*; C415 D2V2S(Power)*; C417 RF-45(2)*; C418 RF-45(2)* RJ-45(1)*

### Layout directives
Length: 24": ISC_SQ_259_1, ISC_SQ_260_1, ISC_SQ_263_1, ISC_SQ_264_1, ISC_SQ_265_1, ISC_SQ_266_1, ISC_SQ_267_1, ISC_SQ_268_1, ISC_SQ_276, ISC_SQ_277
Length: 30ft: ISC_SQ_261_1, ISC_SQ_262_1, ISC_SQ_269_1, ISC_SQ_270_1
Length: 64": ISC_SQ_259_2, ISC_SQ_260_2, ISC_SQ_263_2, ISC_SQ_264_2, ISC_SQ_269_2, ISC_SQ_270_2, ISC_SQ_271, ISC_SQ_273, ISC_SQ_410
Length: 80": ISC_SQ_261_2, ISC_SQ_262_2, ISC_SQ_272
Length: 52": ISC_SQ_265_2, ISC_SQ_266_2, ISC_SQ_274
Length: 36": ISC_SQ_278
Length: ": ISC_SQ_267_2, ISC_SQ_268_2, ISC_SQ_279, ISC_SQ_280, ISC_SQ_281, ISC_SQ_282, ISC_SQ_464, ISC_SQ_465

### Notes on the sheet
- (near C413) Flipper
- Optical Fiber Switch
- Key
- Dot Identifies Cable Shield Terminating to Backshell
- New Cameras per Table Feedthrough Panel
- D1200813, U41
- Pin With Triangle Indicates Pin on Rear or the Like
- Pin With No Triangle Indicates Pin on Front or the Like
- Light Blue Symbols Are In-Vacuum
- Yellow Symbols Are In-Air

### Library data of the parts
C228 C417-C419 = Patch Panel GigE Camera: Patch Panel (D1200813); Serial: Sxxxxxxx; System: ISC
C236 C420-C424 = Motorized Flipper: Serial: Sxxxxxxx; System: ISC
C237 C426-C428 = Camera GigE: Serial: Sxxxxxxx; System: ISC
C412 = SQZ Concentrator Flipper: Serial: Sxxxxxxx; System: ISC
C413-C415 = Patch Panel Motorized Flipper: Patch Panel (D1700169); Serial: Sxxxxxxx; System: ISC
C416 = Patch Panel Optical Fiber Switch: Patch Panel (D1700326); Serial: Sxxxxxxx; System: ISC
C425 = Optical Fiber Switch: Optical Fiber Switch Thorlabs OSW12-980-SM; Serial: Sxxxxxxx; System: ISC

## Sheet SqueezerBeckhoff1.SchDoc: Squeezer Beckhoff Interfaces
size B; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 36; SheetTotal: 37; DrawnBy: R.  Abbott; Engineer: R.  Abbott; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.09¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=7¦PrintQuality=-4¦MediaType=1¦DitherType=10¦PaperKind=11x17¦PrintScaleMode=1

### Parts
C129XX  Picomotor Controller 11  DCC: D1100323  Rack: SQZT0-R1  Slot: U1
C242  Picomotor Controller 12  DCC: D1100323  Rack: SQZT7-R1  Slot: U1
C243  Picomotor Four Axes Breakout  DCC: D1101738  Rack: SQZT0  Slot: Cable Tray
C244  Picomotor  DCC: Newport Picomotor  Rack: SQZT7  Slot: OPO REFL polarization 1
C245  Picomotor  DCC: Newport Picomotor  Rack: SQZT7  Slot: FC REFL polarization 1
C246  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: FC FIBR polarization 1
C247  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: FC FIBR polarization 2
C248  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: CLF IR power
C257  D25 Vacuum Feedthrough  Rack: HAM7  Slot: D8-F8
C258  D25 Vacuum Feedthrough  Rack: HAM7  Slot: D8-F9
C282  Tee  (value not drawn)
C432  DCC: D1101691  Rack: SQZT0-Right  Slot: U22  (hidden comment: Patch Panel Picomotor Breakout)
C433  DCC: D1101691  Rack: SQZT0-Right  Slot: U20  (hidden comment: Patch Panel Picomotor Breakout)
C434  DCC: D1700168  Rack: SQZT0-Right  Slot: U18  (hidden comment: Patch Panel Picomotor DB9)  (parts A,B of 2)
C435  DCC: D1101691  Rack: SQZT7-RightBottom  Slot: U37  (hidden comment: Patch Panel Picomotor Breakout)
C436  Picomotor Four Axes Breakout  DCC: D1101738  Rack: SQZT0  Slot: Cable Tray
C437  Picomotor Four Axes Breakout  DCC: D1101738  Rack: SQZT0  Slot: Cable Tray
C438  Picomotor Four Axes Breakout  DCC: D1101738  Rack: SQZT0  Slot: Cable Tray
C439  Picomotor Four Axes Breakout  DCC: D1101738  Rack: SQZT7  Slot: Cable Tray
C440  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: FIBR polarization 1
C441  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: FIBR polarization 2
C442  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: FIBR polarization 3
C443  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: SHG FIBR polarization 1
C444  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: SHG FIBR polarization 2
C445  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: CLF FIBR polarization 1
C446  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: CLF FIBR polarization 2
C447  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: SHG GR power
C449  Picomotor  DCC: Newport Picomotor  Rack: SQZT0  Slot: Seed IR power
C450  Picomotor  DCC: Newport Picomotor  Rack: SQZT7  Slot: GR BEAT polarization 1
C451  Picomotor tip-tilt  DCC: Newport Picomotor  Rack: SQZT0  Slot: SHG Steering 1
C452  Picomotor tip-tilt  DCC: Newport Picomotor  Rack: SQZT0  Slot: SHG Steering 2

### Ports
ISC_SQ_85 (see ISC_C2_SH2[4B]), ISC_SQ_86 (see ISC_C2_SH2[4B]), ISC_SQ_440 (see ISC_C2_SH2[4B]), ISC_SQ_441 (see ISC_C2_SH2[4B]), Ties to Other_Sheets

### Nets
ISC_SQ_85: C129XX.D25M(Controls) ; port ISC_SQ_85
ISC_SQ_86: C129XX.D25F(Readbacks) ; port ISC_SQ_86
ISC_SQ_235: C436.RJ-11(1X) C440.RJ-11(Pico)
ISC_SQ_236: C436.RJ-11(1Y) C441.RJ-11(Pico)
ISC_SQ_237: C436.RJ-11(2X) C442.RJ-11(Pico)
ISC_SQ_238: C437.RJ-11(1X) C443.RJ-11(Pico)
ISC_SQ_239: C437.RJ-11(1Y) C444.RJ-11(Pico)
ISC_SQ_240: C436.RJ-11(2Y) C447.RJ-11(Pico)
ISC_SQ_241: C437.RJ-11(2X) C445.RJ-11(Pico)
ISC_SQ_242: C437.RJ-11(2Y) C446.RJ-11(Pico)
ISC_SQ_243: C248.RJ-11(Pico) C438.RJ-11(2Y)
ISC_SQ_244: C243.RJ-11(1X) C244.RJ-11(Pico)
ISC_SQ_392: C129XX.D25F(Chan_1-4_Outputs) C432.D25M(Pico)
ISC_SQ_393: C129XX.D25F(Chan_5-8_Outputs) C433.D25M(Pico)
ISC_SQ_394: C432.D9F C436.D9M(IN)
ISC_SQ_395: C432.D9F C437.D9M(IN)
ISC_SQ_396: C433.D9F C438.D9M(IN)
ISC_SQ_397: C433.D9F C439.D9M(IN)
ISC_SQ_398: C434.D9F(A)
ISC_SQ_399: C243.D9M(IN) C435.D9F
ISC_SQ_400: C438.RJ-11(2X) C449.RJ-11(Pico)
ISC_SQ_411: C439.RJ-11(1X) C451.RJ-11(Pico_X)
ISC_SQ_412: C439.RJ-11(1Y) C451.RJ-11(Pico_Y)
ISC_SQ_413: C439.RJ-11(2X) C452.RJ-11(Pico_X)
ISC_SQ_414: C439.RJ-11(2Y) C452.RJ-11(Pico_Y)
ISC_SQ_440: C242.D25M(Controls) ; port ISC_SQ_440
ISC_SQ_441: C242.D25F(Readbacks) ; port ISC_SQ_441
ISC_SQ_466: C246.RJ-11(Pico) C438.RJ-11(1X)
ISC_SQ_467: C247.RJ-11(Pico) C438.RJ-11(1Y)
ISC_SQ_468: C243.RJ-11(2X) C245.RJ-11(Pico)
ISC_SQ_469: C243.RJ-11(2Y) C450.RJ-11(Pico)
ISC_SQ_470: C242.D25F(Chan_1-4_Outputs) C257.D25M(Vac._Side)
ISC_SQ_471: C258.D25M(Vac._Side) C282.D25F
ISC_SQ_527: C242.D25F(Chan_5-8_Outputs) C282.D25MM
NetC282_D25F: C282.D25F C435.D25M(Pico)

Not connected (* = marked no-connect by the designer): C129XX Conec-3(+24VDC)* RJ-11(X1)*; C242 Conec-3(+24VDC)* RJ-11(X1)*; C434 D9M(A)*

### Layout directives
Length: 2ft: ISC_SQ_392, ISC_SQ_393, ISC_SQ_527
Length: 48ft: ISC_SQ_398
Length: 8": ISC_SQ_397
Length: ft: ISC_SQ_394, ISC_SQ_395, ISC_SQ_396, ISC_SQ_399
Length: 0": ISC_SQ_235, ISC_SQ_236, ISC_SQ_237, ISC_SQ_238, ISC_SQ_239, ISC_SQ_240, ISC_SQ_241, ISC_SQ_242, ISC_SQ_243, ISC_SQ_244, ISC_SQ_400, ISC_SQ_411, ISC_SQ_412, ISC_SQ_413, ISC_SQ_414, ISC_SQ_466, ISC_SQ_467, ISC_SQ_468, ISC_SQ_469
DCC: D2100101-v1: ISC_SQ_527
Length: 50ft: ISC_SQ_470, ISC_SQ_471

### Notes on the sheet
- D1700308
- Key
- Dot Identifies Cable Shield Terminating to Backshell
- Pin With Triangle Indicates Pin on Rear or the Like
- Pin With No Triangle Indicates Pin on Front or the Like
- Light Blue Symbols Are In-Vacuum
- Yellow Symbols Are In-Air

### Library data of the parts
C129XX C242 = Picomotor Driver: Serial: Sxxxxxxx; System: ISC
C243 C436-C439 = Picomotor Four Axes Breakout: Serial: Sxxxxxxx; System: ISC
C244-C248 C440-C447 C449 C450 = Picomotor: Serial: Sxxxxxxx; System: ISC
C257 C258 = VacFeedD25: Serial: Sxxxxxxx; System: ISC
C282 = TNC Tee: Tee (TNC); Serial: Sxxxxxxx; System: ISC; DCC: D2100101; Rack: SQZT7-R1; Slot: U1
C432 C433 C435 = Patch Panel Picomotor Breakout: Patch Panel (D1101691); Serial: Sxxxxxxx; System: ISC
C434 = Patch Panel Picomotor DB9: Patch Panel (D1700168); Serial: Sxxxxxxx; System: ISC
C451 C452 = Picomotor 2-axes: Serial: Sxxxxxxx; System: ISC

## Sheet SqueezerBeckhoff2.SchDoc: Squeezer Beckhoff Interfaces
size B; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 37; SheetTotal: 37; DrawnBy: R.  Abbott; Engineer: R.  Abbott; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.09¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=7¦PrintQuality=-4¦MediaType=1¦DitherType=10¦PaperKind=11x17¦PrintScaleMode=1

### Parts
C274  SQZ4 EtherCat  DCC: D2000504  Rack: SQZ-C1  Slot: U7
C294  SQZ5 EtherCat  DCC: D2300323  Rack: SQZ-C1  Slot: U3
C429  SQZ1 EtherCat  DCC: D1002961  Rack: SQZ-C1  Slot: U19
C430  SQZ2 EtherCat  DCC: D1600507  Rack: SQZ-C1  Slot: U15
C431  SQZ3 EtherCat  DCC: D1600509  Rack: SQZ-C1  Slot: U11

### Ports
AOM Driver GR (see SqueezerRfDistribution[4D]), AOM Driver IR (see SqueezerRfDistribution[4D]), AUX SQZ (see SqueezerConcentrators[1D]), BDIV HAM7 (see SqueezerInVacControls[6C]), CM_CLF_A (see SqueezerRfControls2[4B]), CM_CLF_B (see SqueezerRfControls2[4B]), CM_FC_A (see SqueezerRfControls2[3C]), CM_FC_B (see SqueezerRfControls2[3C]), CM_LO_A (see SqueezerRfControls1[3C]), CM_LO_B (see SqueezerRfControls1[3C]), CM_OPO_A (see SqueezerRfControls1[3B]), CM_OPO_B (see SqueezerRfControls1[3B]), CM_PMC_A (see SqueezerRfControls2[4D]), CM_PMC_B (see SqueezerRfControls2[4D]), CM_SHG_A (see SqueezerRfControls1[3B]), CM_SHG_B (see SqueezerRfControls1[3B]), DCPD 7 (see SqueezerConcentrators[2C]), DCPD 8 (see SqueezerConcentrators[2A]), DCPD 9 (see SqueezerConcentrators[1B]), DCPD 11 (see SqueezerConcentrators[1D]), Delay FC (see SqueezerRfControls2[1B]), Delay PMC (see SqueezerRfControls2[1B]), Delay_CLF1 (see SqueezerRfControls2[1A]), Delay_CLF2 (see SqueezerRfControls2[1A]), Delay_CLF3 (see SqueezerRfControls2[1A]), Delay_CLF4 (see SqueezerRfControls2[1A]), Delay_OPO (see SqueezerRfControls1[1A]), Delay_SHG (see SqueezerRfControls1[1A]), FC QPDs (see SqueezerWfsWiring[5B]), Flipper (see SqueezerMiscellaneous[1A]), LaserDiag (see SqueezerRfControls1[6C]), OFI Therm. (see SqueezerInVacControls[5B]), OFI_TEC (see SqueezerInVacControls[5B]), OPO_TEC (see SqueezerInVacControls[6C]), PLL Int (see SqueezerRfControls2[5A]), PZT_Driver_A (see SqueezerRfControls1[5A]), SFI1 Therm. (see SqueezerInVacControls[5B]), SFI1_TEC (see SqueezerInVacControls[5B]), SFI2 Therm. (see SqueezerInVacControls[5B]), SFI2_TEC (see SqueezerInVacControls[5B]), SHG_TEC (see SqueezerRfControls1[5A]), Shutter SQZT7 (see SqueezerConcentrators[1C]), Therm. 8_1 (see SqueezerInVacControls[6C]), Therm. 8_2 (see SqueezerInVacControls[6C]), Therm. 8_3 (see SqueezerInVacControls[6C]), Ties to_Other Sheets, TTFSS (see SqueezerRfControls1[5D]), VCO_SQZ_FC (see SqueezerRfControls2[6C]), VCO_SQZ_Laser (see SqueezerRfControls1[5C]), VCXO_ADF (see SqueezerRfControls2[4A]), VCXO_CLF (see SqueezerRfControls2[6B]), VCXO_RLF (see SqueezerRfControls2[4A])

### Nets
ISC_SQ_79: C430.D15M(PZT_A) ; port PZT_Driver_A
ISC_SQ_310: C430.D15F(OPO_TEC_Slot_2) ; port OPO_TEC
ISC_SQ_311: C430.D15F(SHG_TEC_Slot_3) ; port SHG_TEC
ISC_SQ_312: C430.D25M(VCXO_Slot_4) ; port VCXO_CLF
ISC_SQ_313: C430.D37M(CM/A1_Slot_5) ; port CM_LO_A
ISC_SQ_314: C430.D37M(CM/A2_Slot_6) ; port CM_LO_B
ISC_SQ_315: C430.D25F(Delay_A_Slot_7) ; port Delay_CLF2
ISC_SQ_316: C430.D25F(Delay_B_Slot_8) ; port Delay_CLF3
ISC_SQ_317: C430.D37M(CM/B1_Slot_9) ; port CM_CLF_A
ISC_SQ_318: C430.D37M(CM/B2_Slot_10) ; port CM_CLF_B
ISC_SQ_319: C430.D25F(Delay_C_Slot_11) ; port Delay_CLF1
ISC_SQ_320: C430.D25F(Delay_D_Slot_12) ; port Delay_CLF4
ISC_SQ_321: C431.D37M(TTFSS_Slot_6) ; port TTFSS
ISC_SQ_322: C431.D25M(Flipper_Slot_7) ; port Flipper
ISC_SQ_323: C431.D37M(DCPD_Conc._7_Slot_9) ; port DCPD 7
ISC_SQ_324: C431.D37M(DCPD_Conc._8_Slot_10) ; port DCPD 8
ISC_SQ_325: C431.D25M(Laser_Diag._Slot_11) ; port LaserDiag
ISC_SQ_327: C431.M12F(ThermistorsSlot_8_1) ; port Therm. 8_1
ISC_SQ_328: C431.M12F(ThermistorsSlot_8_2) ; port Therm. 8_2
ISC_SQ_329: C431.M12F(ThermistorsSlot_8_3) ; port Therm. 8_3
ISC_SQ_334: C429.D25F(Delay_A_Slot_3) ; port Delay_OPO
ISC_SQ_335: C429.D25F(Delay_B_Slot_4) ; port Delay_SHG
ISC_SQ_336: C429.D25M(VCO_Slot_5) ; port VCO_SQZ_Laser
ISC_SQ_337: C429.D37M(CM/A1_Slot_6) ; port CM_OPO_A
ISC_SQ_338: C429.D37M(CM/A2_Slot_7) ; port CM_OPO_B
ISC_SQ_339: C429.D37M(CM/B1_Slot_8) ; port CM_SHG_A
ISC_SQ_340: C429.D37M(CM/B2_Slot_9) ; port CM_SHG_B
ISC_SQ_417: C431.D37M(AOM_Driver_GR_Slot_5) ; port AOM Driver GR
ISC_SQ_418: C431.D37M(AOM_Driver_IR_Slot_4) ; port AOM Driver IR
ISC_SQ_477: C274.D25M(FC_QPDs_Slot_2) ; port FC QPDs
ISC_SQ_485: C274.D25M(VCXO_ADF_Slot_4) ; port VCXO_ADF
ISC_SQ_486: C274.D25M(VCXO_RLF_Slot_3) ; port VCXO_RLF
ISC_SQ_487: C274.D15F(OFI_TEC_Slot_7) ; port OFI_TEC
ISC_SQ_488: C274.D15F(SF1_TEC_Slot_5) ; port SFI1_TEC
ISC_SQ_489: C274.D15F(Spare_TEC_Slot_8) ; port SFI2_TEC
ISC_SQ_490: C274.D37M(CM_/1_Slot_10) ; port CM_FC_A
ISC_SQ_491: C274.D37M(CM_/2_Slot_11) ; port CM_FC_B
ISC_SQ_492: C274.D25M(VCO_Slot_12) ; port VCO_SQZ_FC
ISC_SQ_493: C274.M12F(ThermistorsSlot_9_1) ; port OFI Therm.
ISC_SQ_494: C274.M12F(ThermistorsSlot_9_2) ; port SFI1 Therm.
ISC_SQ_495: C274.M12F(ThermistorsSlot_9_3) ; port SFI2 Therm.
ISC_SQ_496: C274.D15M(Shutter_A) ; port Shutter SQZT7
ISC_SQ_497: C274.D25M(PLL_Integration_Slot_1) ; port PLL Int
ISC_SQ_498: C294.D25F(Delay_Slot_10) ; port Delay FC
ISC_SQ_501: C431.D37M(DCPD_Conc._9_Slot_3) ; port DCPD 9
ISC_SQ_509: C431.D37M(Aux_Conc._1_Slot_2) ; port AUX SQZ
ISC_SQ_524: C274.D9F(Diverter_C) ; port BDIV HAM7
ISC_SQ_540: C294.D37M(CM_/1_Slot_7) ; port CM_PMC_A
ISC_SQ_541: C294.D37M(CM_/2_Slot_8) ; port CM_PMC_B
ISC_SQ_542: C294.D25F(Delay_Slot_9) ; port Delay PMC
ISC_SQ_543: C294.D37M(Aux._Conc._11_Slot_6) ; port DCPD 11
ISC_SQ_553: C429.RJ-45(Port_1) C430.RJ-45(IN)
ISC_SQ_554: C430.RJ-45(OUT) C431.RJ-45(IN)
ISC_SQ_555: C274.RJ-45(IN) C431.RJ-45(OUT)
ISC_SQ_556: C274.RJ-45(OUT) C294.RJ-45(IN)

Not connected (* = marked no-connect by the designer): C274 Conec-3(+24VDC)* D25F(Delay_Slot_13)*; C294 Conec-3(+24VDC)* tbd(Slot_1)*; C429 Conec-3(+24VDC)* LC-Fiber(IN)* RJ-44(Port_2)* tbd(Slot_1)*; C430 Conec-3(+24VDC)* tbd(Slot_1)*; C431 blank(Port_1)* Conec-3(+24VDC)* tbd(Slot_1)*

### Layout directives
Length: 144ft: ISC_SQ_79, ISC_SQ_310, ISC_SQ_312, ISC_SQ_313, ISC_SQ_314, ISC_SQ_315, ISC_SQ_316, ISC_SQ_317, ISC_SQ_318, ISC_SQ_319, ISC_SQ_320, ISC_SQ_323, ISC_SQ_324, ISC_SQ_327, ISC_SQ_328, ISC_SQ_329, ISC_SQ_334, ISC_SQ_335, ISC_SQ_336, ISC_SQ_337, ISC_SQ_338, ISC_SQ_339, ISC_SQ_340, ISC_SQ_417, ISC_SQ_418
Length: 150ft: ISC_SQ_311, ISC_SQ_321
Length: 155ft: ISC_SQ_325
Length: 165ft: ISC_SQ_322
Length: 130ft: ISC_SQ_477, ISC_SQ_485, ISC_SQ_486, ISC_SQ_487, ISC_SQ_488, ISC_SQ_489, ISC_SQ_490, ISC_SQ_491, ISC_SQ_492, ISC_SQ_493, ISC_SQ_494, ISC_SQ_495, ISC_SQ_497, ISC_SQ_498, ISC_SQ_501, ISC_SQ_509, ISC_SQ_524, ISC_SQ_540, ISC_SQ_541, ISC_SQ_542, ISC_SQ_543
Length: 122ft: ISC_SQ_496

### Notes on the sheet
- Key
- Dot Identifies Cable Shield Terminating to Backshell
- Pin With Triangle Indicates Pin on Rear or the Like
- Pin With No Triangle Indicates Pin on Front or the Like
- Light Blue Symbols Are In-Vacuum
- Yellow Symbols Are In-Air

### Library data of the parts
C274 = SQZ4 EtherCat: Serial: Sxxxxxxx; System: ISC
C294 = SQZ5 EtherCat: Serial: Sxxxxxxx; System: ISC
C429 = SQZ1 EtherCat: Serial: Sxxxxxxx; System: ISC
C430 = SQZ2 EtherCat: Serial: Sxxxxxxx; System: ISC
C431 = SQZ3 EtherCat: Serial: Sxxxxxxx; System: ISC