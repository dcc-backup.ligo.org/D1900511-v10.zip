# Altium project D1900511.PrjPcb (part 4 of 7)

## Sheet ISC_R5_SH1.SchDoc: ISC System Wiring Diagram
size B; DrawnBy: Filiberto Clara; Engineer: Filiberto Clara; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 19; SheetTotal: 37

### Parts
C201  WFS RFPD Interface  DCC: D1101906  Rack: ISC-R5  Slot: U30
C203  ISC Whitening Chassis  DCC: D1002559  Rack: ISC-R5  Slot: U18
C204  QPD Transimpedance Amp V2  DCC: D1002481  Rack: ISC-R5  Slot: U14
C285  WFS RF PatchPanel  DCC: D1100905  Rack: ISC-R5  Slot: U39
C319  Quad I/Q Demodulator WFS Variant  DCC: D0902796  Rack: ISC-R5  Slot: U38
C329  ISC Whitening Chassis  DCC: D1002559  Rack: ISC-R5  Slot: U40
C345  Quad I/Q Demodulator WFS Variant  DCC: D0902796  Rack: ISC-R5  Slot: U37
C355  ISC Whitening Chassis  DCC: D1002559  Rack: ISC-R5  Slot: U35
C360  ISC Whitening Chassis  DCC: D1002559  Rack: ISC-R5  Slot: U16
C363  QPD Transimpedance Amp  DCC: D1002481  Rack: ISC-R5  Slot: U21
C368  ISC Whitening Chassis  DCC: D1002559  Rack: ISC-R5  Slot: U23
C369  QPD Transimpedance Amp  DCC: D1002481  Rack: ISC-R5  Slot: U20

### Ports
ISC_91 (see ISC_C2_SH1[4B]), ISC_130 (see ISC_C1_SH1[1D]), ISC_131 (see ISC_C1_SH1[1D]), ISC_161 (see ISC_C1_SH1[4A]), ISC_162 (see ISC_C1_SH1[4A]), ISC_163 (see ISC_C1_SH1[4A]), ISC_232 (see HAM6_SH1[2B]), ISC_233 (see HAM6_SH1[2C]), ISC_265 (see HAM6_SH1[4A]), ISC_266 (see HAM6_SH1[4A]), ISC_400 (see ISC_C1_SH1[4A]), ISC_401 (see ISC_C1_SH1[4A]), ISC_404 (see HAM6_SH1[2B]), ISC_426 (see ISC_C1_SH1[4B]), ISC_427 (see ISC_C1_SH1[4B]), ISC_502 (see ISC_R5_SH2[4B]), ISC_503 (see ISC_R5_SH2[4B]), ISC_504 (see ISC_R5_SH2[4C]), ISC_505 (see ISC_R5_SH2[4C]), ISC_506 (see ISC_C1_SH1[4A]), ISC_507 (see ISC_C1_SH1[4A]), ISC_508 (see ISC_C1_SH1[4B]), ISC_509 (see ISC_C1_SH1[4B]), ISC_510 (see ISC_R5_SH3[4C]), ISC_511 (see ISC_R5_SH3[4C]), ISC_512 (see ISC_R5_SH3[4C]), ISC_513 (see ISC_R5_SH3[4C]), ISC_514 (see HAM6_SH2[4A]), ISC_515 (see HAM6_SH2[4A]), ISC_516 (see ISC_R5_SH3[4D]), ISC_517 (see ISC_R5_SH3[4D]), ISC_518 (see ISC_R5_SH3[4D]), ISC_519 (see ISC_R5_SH3[4D]), ISC_548 (see ISC_R3_SH1[3C]), ISC_549 (see ISC_R3_SH1[3C]), ISC_555 (see ISC_R5_SH3[4C]), ISC_556 (see ISC_R5_SH3[4C]), ISC_RF40-B/3 (see HAM6_SH2[4B]), ISC_RF40-B/5 (see HAM6_SH2[4B]), ISC_RF41-B/1 (see HAM6_SH2[4B]), ISC_RF41-B/3 (see HAM6_SH2[4B]), ISC_RF41-B/5 (see HAM6_SH2[4B]), ISC_RF42-B/3 (see HAM6_SH2[4C]), ISC_RF42-B/5 (see HAM6_SH2[4C]), ISC_RF43-B/1 (see HAM6_SH2[4C]), ISC_RF43-B/3 (see HAM6_SH2[4C]), ISC_RF43-B/5 (see HAM6_SH2[4C]), ISC_SQ_297 (see ISC_C1_SH1[4A]), SUM_OUT_1 (see ISC_R5_SH3[5A])

### Nets
ISC_38: C203.D25M(An.Sig.In) C369.D25F(To_Whitening)
ISC_39: C204.D25F(To_Whitening) C360.D25M(An.Sig.In)
ISC_130: C201.D9F(Out_Head_1) ; port ISC_130
ISC_131: C201.D9F(Out_Head_2) ; port ISC_131
ISC_161: C203.D9F(AnalogOut0-3) ; port ISC_161
ISC_162: C203.D9F(AnalogOut4-7) ; port ISC_162
ISC_163: C360.D9F(AnalogOut0-3) ; port ISC_163
ISC_232: C369.D25F(PD_Inputs) ; port ISC_232
ISC_233: C204.D25F(PD_Inputs) ; port ISC_233
ISC_265: C201.D15F(Head_1) ; port ISC_265
ISC_266: C201.D15F(Head_2) ; port ISC_266
ISC_400: C368.D9F(AnalogOut0-3) ; port ISC_400
ISC_401: C368.D9F(AnalogOut4-7) ; port ISC_401
ISC_404: C363.D25F(PD_Inputs) ; port ISC_404
ISC_405: C363.D25F(To_Whitening) C368.D25M(An.Sig.In)
ISC_426: C201.D9F(Out_Head_3) ; port ISC_426
ISC_427: C201.D9F(Out_Head_4) ; port ISC_427
ISC_500: C319.D25F(IQOutputs) C329.D25M(An.Sig.In)
ISC_501: C345.D25F(IQOutputs) C355.D25M(An.Sig.In)
ISC_502: C319.D9F(RFMon1&2) ; port ISC_502
ISC_503: C319.D9F(RFMon3&4) ; port ISC_503
ISC_504: C345.D9F(RFMon1&2) ; port ISC_504
ISC_505: C345.D9F(RFMon3&4) ; port ISC_505
ISC_506: C329.D9F(AnalogOut0-3) ; port ISC_506
ISC_507: C329.D9F(AnalogOut4-7) ; port ISC_507
ISC_508: C355.D9F(AnalogOut0-3) ; port ISC_508
ISC_509: C355.D9F(AnalogOut4-7) ; port ISC_509
ISC_510: C329.D37F(BinaryReadback1) ; port ISC_510
ISC_511: C329.D37F(Bin.Cont.2) ; port ISC_511
ISC_512: C355.D37F(BinaryReadback1) ; port ISC_512
ISC_513: C355.D37F(Bin.Cont.2) ; port ISC_513
ISC_514: C201.D15F(Head_3) ; port ISC_514
ISC_515: C201.D15F(Head_4) ; port ISC_515
ISC_516: C368.D37F(BinaryReadback1) ; port ISC_516
ISC_517: C368.D37F(Bin.Cont.2) ; port ISC_517
ISC_518: C203.D37F(BinaryReadback1) ; port ISC_518
ISC_519: C203.D37F(Bin.Cont.2) ; port ISC_519
ISC_548: C319.SMA(LOIN) ; port ISC_548
ISC_549: C345.SMA(LOIN) ; port ISC_549
ISC_555: C360.D37F(BinaryReadback1) ; port ISC_555
ISC_556: C360.D37F(Bin.Cont.2) ; port ISC_556
ISC_R5-RF1: C285.TNC(CH1-1) C319.SMA(RFIN1)
ISC_R5-RF2: C285.TNC(CH2-1) C319.SMA(RFIN2)
ISC_R5-RF3: C285.TNC(CH3-1) C319.SMA(RFIN3)
ISC_R5-RF4: C285.TNC(CH4-1) C319.SMA(RFIN4)
ISC_R5-RF5: C285.TNC(CH1-2) C345.SMA(RFIN1)
ISC_R5-RF6: C285.TNC(CH2-2) C345.SMA(RFIN2)
ISC_R5-RF7: C285.TNC(CH3-2) C345.SMA(RFIN3)
ISC_R5-RF8: C285.TNC(CH4-2) C345.SMA(RFIN4)
ISC_RF40-B/3: C285.TNC(CH2-1) ; port ISC_RF40-B/3
ISC_RF40-B/5: C285.TNC(CH3-1) ; port ISC_RF40-B/5
ISC_RF41-B/1: C285.TNC(TestIN-1) ; port ISC_RF41-B/1
ISC_RF41-B/3: C285.TNC(CH4-1) ; port ISC_RF41-B/3
ISC_RF41-B/5: C285.TNC(CH1-1) ; port ISC_RF41-B/5
ISC_RF42-B/3: C285.TNC(CH2-2) ; port ISC_RF42-B/3
ISC_RF42-B/5: C285.TNC(CH3-2) ; port ISC_RF42-B/5
ISC_RF43-B/1: C285.TNC(TestIN-2) ; port ISC_RF43-B/1
ISC_RF43-B/3: C285.TNC(CH4-2) ; port ISC_RF43-B/3
ISC_RF43-B/5: C285.TNC(CH1-2) ; port ISC_RF43-B/5
ISC_SQ_297: C360.D9F(AnalogOut4-7) ; port ISC_SQ_297
SUM_OUT_1: C204.BNC(SUM_OUT_1) ; port SUM_OUT_1

Not connected (* = marked no-connect by the designer): C201 Conec-3(DC+/-18)*; C203 Conec-3(DC+/-18)*; C204 Conec-3(DC+/-18)*; C285 SMA(TestIN-1)*; C319 BNC(I-Mon1)* Conec-3(DC+/-18)*; C329 Conec-3(DC+/-18)*; C345 BNC(I-Mon1)* Conec-3(DC+/-18)*; C355 Conec-3(DC+/-18)*; C360 Conec-3(DC+/-18)*; C363 Conec-3(DC+/-18)*; C368 Conec-3(DC+/-18)*; C369 Conec-3(DC+/-18)*

### Layout directives
Length: 5ft: ISC_38, ISC_39, ISC_405, ISC_500, ISC_501
Length: 25ft: ISC_232, ISC_233, ISC_404
Length: 10": ISC_R5-RF5, ISC_R5-RF6, ISC_R5-RF7, ISC_R5-RF8
Length: V?: ISC_514, ISC_515, ISC_RF40-B/3, ISC_RF40-B/5, ISC_RF41-B/1, ISC_RF41-B/3, ISC_RF41-B/5, ISC_RF42-B/3, ISC_RF42-B/5, ISC_RF43-B/1, ISC_RF43-B/3, ISC_RF43-B/5
Length: 7": ISC_R5-RF1, ISC_R5-RF2, ISC_R5-RF3, ISC_R5-RF4
Length: 2.5ft: ISC_502, ISC_503, ISC_504, ISC_505

### Notes on the sheet
- ISC-R5 Rack (ASC)
- LO_A WFS 36MHz
- (near C285) bottom
- (near C285) top
- LO_B WFS 36MHz
- AS_A
- ASC_ADC5_3
- AS_B
- LO_A
- LO_B
- ASC_ADC5_4
- Extra cable
- ASC_AS_C/LO_C
- ASC_OMC_A/B
- ASC-OMC_A/B
- ASC_OMC_C/D

### Library data of the parts
C201 = WFS RFPD Interface: Serial: Sxxxxxxx; System: ISC
C203 C329 C355 C360 C368 = ISC Whitening: Serial: Sxxxxxxx
C204 = QPD Transimpedance Amp V2: Serial: Sxxxxxxx; System: ISC
C285 = WFS RFPD PatchPanel: Serial: Sxxxxxxx; System: ISC
C319 C345 = QuadIQdemod_WFS: Serial: Sxxxxxxx; System: ISC
C363 C369 = QPD Transimpedance Amp: Serial: Sxxxxxxx; System: ISC

## Sheet ISC_R5_SH2.SchDoc: ISC System Wiring Diagram
size B; DrawnBy: Filiberto Clara; Engineer: Filiberto Clara; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 20; SheetTotal: 37

### Parts
C210  Dual Dsub PatchPanel  DCC: D1201450  Rack: ISC-R5  Slot: U17
C270  ISC Aux. Conc. 4  DCC: D1201349  Rack: ISC-R5  Slot: U12
C370  3.125MHz Squeezer Pickoff  DCC: D2100759  Rack: ISC-R5  Slot: U42
C371  LSC RFPD Interface  DCC: D1102079  Rack: ISC-R5  Slot: U29
C378  2-Chan Demodulator  DCC: D1000181  Rack: ISC-R5  Slot: U33
C382  LSC Demod Concentrator  DCC: D1100691  Rack: ISC-R5  Slot: U32
C386  Dual LSC RFPD PatchPanel  DCC: D2400267  Rack: ISC-R5  Slot: U34
C448  ASC Demod Concentrator  DCC: D1100696  Rack: ISC-R5  Slot: U39
C464  OMC DCPD Whitening Chassis  DCC: D2200215  Rack: ISC-R5  Slot: U27
C465  OMC DCPD Whitening Chassis  DCC: D2200215  Rack: ISC-R5  Slot: U25
C466  OMC DCPD Panel  DCC: D2400248  Rack: ISC-R5  Slot: U26

### Ports
ISC_92 (see ISC_C2_SH2[4C]), ISC_93 (see ISC_C2_SH2[4C]), ISC_94 (see ISC_C2_SH2[4D]), ISC_242 (see ISC_C1_SH1[4B]), ISC_302 (see ISC_C1_SH2[1D]), ISC_307 (see HAM6_SH1[2A]), ISC_329 (see ISC_C2_SH2[4C]), ISC_439 (see HAM6_SH2[2B]), ISC_440 (see HAM6_SH2[2B]), ISC_441 (see HAM6_SH2[2B]), ISC_442 (see HAM6_SH2[2B]), ISC_443 (see ISC_C2_SH2[4D]), ISC_445, ISC_502 (see ISC_R5_SH1[5B]), ISC_503 (see ISC_R5_SH1[5B]), ISC_504 (see ISC_R5_SH1[5B]), ISC_505 (see ISC_R5_SH1[5B]), ISC_520 (see HAM6_SH1[2A]), ISC_534 (see ISC_C1_SH1[4B]), ISC_536 (see ISC_R5_SH3[1A]), ISC_537 (see ISC_R5_SH3[1A]), ISC_547 (see ISC_C1_SH2[4B]), ISC_550 (see ISC_R3_SH1[3C]), ISC_551 (see ISC_R3_SH1[3B]), ISC_552 (see HAM6_SH2[2A]), ISC_554 (see ISC_C1_SH2[4B]), ISC_RF44-B/1 (see HAM6_SH2[2A]), ISC_RF44-B/2 (see HAM6_SH2[2B]), ISC_RF44-B/3 (see HAM6_SH2[2B]), ISC_RF44-B/4 (see HAM6_SH2[2B]), ISC_RF44-B/5 (see HAM6_SH2[2B]), ISC_SQ_506 (see ISC_R3_SH1[5A])

### Nets
ISC_92: C382.D37F(CTRL) ; port ISC_92
ISC_93: C448.D37F(CTRL_A) ; port ISC_93
ISC_94: C466.D37F(Controls) ; port ISC_94
ISC_242: C466.D9F(Bias_Mon) ; port ISC_242
ISC_302: C466.D9F(Outputs) ; port ISC_302
ISC_307: C464.D25F(Preamp) ; port ISC_307
ISC_329: C270.D37F(CTRL) ; port ISC_329
ISC_439: C370.N(A) ; port ISC_439
ISC_440: C370.N(B) ; port ISC_440
ISC_441: C370.N(C) ; port ISC_441
ISC_442: C370.N(D) ; port ISC_442
ISC_443: C370.D25F(Controls) ; port ISC_443
ISC_445: C270.D9F(PDDC_1-4_OUT) ; port ISC_445
ISC_502: C448.D9M(RF_Demodulator_1A) ; port ISC_502
ISC_503: C448.D9M(RF_Demodulator_2A) ; port ISC_503
ISC_504: C448.D9M(RF_Demodulator_3A) ; port ISC_504
ISC_505: C448.D9M(RF_Demodulator_4A) ; port ISC_505
ISC_520: C465.D25F(Preamp) ; port ISC_520
ISC_521: C464.D9F(Outputs) C465.D9F(Outputs) C466.D9M(Outputs)
ISC_522: C464.D9F(Bias_Mon) C465.D9F(Bias_Mon) C466.D9M(Bias_Mon)
ISC_523: C464.D9M(From_DAC) C465.D9M(From_DAC) C466.D9F(From_DAC) C466.D9M(PZT_Bias_1)
ISC_524: C464.D37F(Binary_Controls) C465.D37F(Binary_Controls) C466.D37M(Binary_Controls)
ISC_533: C378.D15F(Controls) C382.D15M(Demod_RF_Levels_1)
ISC_534: C378.D9F(DAQ) ; port ISC_534
ISC_536: C466.D9F(PZT_Bias_1) ; port ISC_536
ISC_537: C466.D9F(PZT_Bias_2) ; port ISC_537
ISC_547: C466.D9M(From_DAC) ; port ISC_547
ISC_550: C378.TNC(LO1) ; port ISC_550
ISC_551: C378.TNC(LO2) ; port ISC_551
ISC_552: C371.D9F(Head_1) ; port ISC_552
ISC_554: C371.D9F(AN_OUT_To_AA) ; port ISC_554
ISC_R5-RF9: C378.SMA(RFOut1) C386.SMA(RF1_PD1)
ISC_R5-RF10: C378.SMA(RFIn2) C386.SMA(RF2_PD2)
ISC_RF44-B/1: C386.TNC(RF2_PD2) ; port ISC_RF44-B/1
ISC_RF44-B/2: C386.TNC(RF1_PD2) ; port ISC_RF44-B/2
ISC_RF44-B/3: C386.TNC(TestIn1) ; port ISC_RF44-B/3
ISC_RF44-B/4: C386.TNC(TestOut2) ; port ISC_RF44-B/4
ISC_RF44-B/5: C386.TNC(DC_PD2) ; port ISC_RF44-B/5
ISC_SQ_506: C370.N(Sum) ; port ISC_SQ_506

Not connected (* = marked no-connect by the designer): C210 D9M(DSUB1)* LEMO 2P(1a)* TNC(1a)*; C270 BNC(PD_Mon_1)* Conec-3(+/-17VDC)* D9M(PDDC_1-4_IN)* D25F(OMCR)* TNC(PD_Amp._(In)_PD1)*; C370 BNC(M1)* Conec-3(DC+/-17)*; C371 Conec-3(DC+/-18)*; C378 BNC(I-Mon1)* Conec-3(DC+/-18)*; C382 D9M(Demod_IQ_Wh._1)*; C464 BNC(A+)* Conec-3(DC+/-18)*; C465 BNC(A+)* Conec-3(DC+/-18)*

### Layout directives
Length: 25ft: ISC_307, ISC_439, ISC_440, ISC_441, ISC_442
Length: 8": ISC_R5-RF9, ISC_R5-RF10
Length: 2.5ft: ISC_533
Length: V?: ISC_520, ISC_552, ISC_RF44-B/1, ISC_RF44-B/2, ISC_RF44-B/3, ISC_RF44-B/4, ISC_RF44-B/5
Length: 2ft: ISC_521, ISC_522, ISC_523, ISC_524
DCC: D2400247: ISC_524
DCC: D2400251: ISC_523
DCC: D2400246: ISC_521, ISC_522
Length: 5ft: ISC_536, ISC_537

### Notes on the sheet
- ISC-R5 Rack (LSC)
- DCPD A & B
- (near C464) 1
- DCPD C & D
- (near C465) 2
- (near C466) 3
- (near C466) 4

### Library data of the parts
C210 = Dual Dsub PatchPanel: Serial: Sxxxxxxx; System: ISC
C270 = ISC Aux. Conc. 4: Serial: Sxxxxxxx
C370 = 3.125MHz Squeezer Pickoff: Serial: Sxxxxxxx; System: ISC
C371 = LSC RFPD Interface: Serial: Sxxxxxxx; System: ISC
C378 = 2-Chan Demod: Serial: Sxxxxxxx; System: ISC
C382 = LSC Demod Concentrator: Serial: Sxxxxxxx; System: ISC
C386 = LSC RFPD PatchPanel Dual: Serial: Sxxxxxxx; System: ISC
C448 = ASC Demod Concentrator: Serial: Sxxxxxxx; System: ISC
C464 C465 = OMC DCPD Whitening Chassis: Serial: Sxxxxxxx; System: ISC
C466 = OMC DCPD Panel: Serial: Sxxxxxxx; System: ISC

## Sheet ISC_R5_SH3.SchDoc: ISC System Wiring Diagram
size B; DrawnBy: Filiberto Clara; Engineer: Filiberto Clara; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 21; SheetTotal: 37

### Parts
C207  Aux. Conc. 1  DCC: D1102065  Rack: ISC-R5  Slot: U13
C209  OMC Piezo Driver  DCC: D1300485-v2  Rack: ISC-R5  Slot: U10
C213  Fast Shutter Driver  DCC: D1400078  Rack: ISC-R5  Slot: U7
C214  Shutter Controller  DCC: D1102312  Rack: ISC-R5  Slot: U2
C215  Picomotor Driver  DCC: D1100323  Rack: ISC-R5  Slot: U2
C281  Tee  (value not drawn)
C468  OMC Piezo Driver  DCC: D1300485-v2  Rack: ISC-R5  Slot: U11
C469  Fast Shutter Driver  DCC: D1400078  Rack: ISC-R5  Slot: U5
C470  Tee  (value not drawn)
C471  Tee  (value not drawn)
C472  OMC PZT/Fast Shutter Concentrator  DCC: D2400260  Rack: ISC-R5  Slot: U9
C473  Whitening Controls Concentrator  DCC: D2400263  Rack: ISC-R5  Slot: U36
C474  Whitening Controls Concentrator  DCC: D2400263  Rack: ISC-R5  Slot: U19

### Ports
ISC_182 (see ISC_C2_SH2[4B]), ISC_183 (see ISC_C2_SH2[4B]), ISC_234 (see HAM6_SH1[2C]), ISC_323 (see ISC_C2_SH2[2C]), ISC_327 (see ISC_C2_SH2[4C]), ISC_402 (see ISC_C2_SH1[4C]), ISC_403 (see ISC_C2_SH1[4C]), ISC_406 (see ISC_C1_SH2[4B]), ISC_407 (see ISC_C1_SH1[4B]), ISC_409 (see HAM6_SH1[2B]), ISC_423 (see ISC_C2_SH2[4D]), ISC_510 (see ISC_R5_SH1[6A]), ISC_511 (see ISC_R5_SH1[6A]), ISC_512 (see ISC_R5_SH1[6B]), ISC_513 (see ISC_R5_SH1[6B]), ISC_516 (see ISC_R5_SH1[5D]), ISC_517 (see ISC_R5_SH1[5D]), ISC_518 (see ISC_R5_SH1[5D]), ISC_519 (see ISC_R5_SH1[5D]), ISC_525 (see HAM6_SH1[2B]), ISC_526 (see HAM6_SH1[2C]), ISC_527 (see HAM6_SH1[2C]), ISC_528 (see ISC_C1_SH1[4B]), ISC_536 (see ISC_R5_SH2[4D]), ISC_537 (see ISC_R5_SH2[4D]), ISC_553 (see ISC_C1_SH2[1C]), ISC_555 (see ISC_R5_SH1[5C]), ISC_556 (see ISC_R5_SH1[5C]), SUM_OUT_1 (see ISC_R5_SH1[3C])

### Nets
ISC_182: C215.D25M(Controls) ; port ISC_182
ISC_183: C215.D25F(Readbacks) ; port ISC_183
ISC_234: C215.D25F(Chan_1-4_Outputs) ; port ISC_234
ISC_323: C214.D15F(Controls) ; port ISC_323
ISC_327: C207.D37F(Controls) ; port ISC_327
ISC_402: C473.D37F(Controls) ; port ISC_402
ISC_403: C474.D37F(Controls) ; port ISC_403
ISC_406: C472.D9M(Driver) ; port ISC_406
ISC_407: C472.D9F(Lo_Mon) ; port ISC_407
ISC_409: C468.D25F(To_OMC) ; port ISC_409
ISC_423: C472.D25F(Fast_Shutter_In) ; port ISC_423
ISC_510: C473.D37M(1Hi) ; port ISC_510
ISC_511: C473.D37M(1Lo) ; port ISC_511
ISC_512: C473.D37M(2Hi) ; port ISC_512
ISC_513: C473.D37M(2Lo) ; port ISC_513
ISC_516: C474.D37M(1Hi) ; port ISC_516
ISC_517: C474.D37M(2Lo) ; port ISC_517
ISC_518: C474.D37M(3Lo) ; port ISC_518
ISC_519: C474.D37M(4Lo) ; port ISC_519
ISC_525: C209.D25F(To_OMC) ; port ISC_525
ISC_526: C469.MIL(To_Fast_Shutter) ; port ISC_526
ISC_527: C213.MIL(To_Fast_Shutter) ; port ISC_527
ISC_528: C472.D9F(Hi_Mon) ; port ISC_528
ISC_529: C209.D9F(Length_HV_Mon) C472.D9M(Hi_HV_Mon)
ISC_530: C209.D9M(Length_HV_Drive) C472.D9F(Hi_HV_Drive)
ISC_531: C209.D9M(LV_Drive) C472.D9F(Hi_LV_Drive)
ISC_532: C209.D9F(LV_Mon) C472.D9M(Hi_LV_Mon)
ISC_535: C209.D9F(Bias_HV_Mon) C472.D9M(Hi_Bias_Mon)
ISC_536: C468.D9M(Bias_HV_Drive) ; port ISC_536
ISC_537: C209.D9M(Bias_HV_Drive) ; port ISC_537
ISC_538: C207.TNC(Analog_Input_4) C472.TNC(Lo_LV_Mon)
ISC_539: C207.TNC(Analog_Input_1) C472.TNC(Hi_LV_Mon)
ISC_540: C469.D25F(Remote_Interface) C472.D25M(Fast_Shutter_A)
ISC_541: C213.D25F(Remote_Interface) C472.D25M(Fast_Shutter_B)
ISC_542: C468.D9F(Length_HV_Mon) C472.D9M(Lo_HV_Mon)
ISC_543: C468.D9M(Length_HV_Drive) C472.D9F(Lo_HV_Drive)
ISC_544: C468.D9M(LV_Drive) C472.D9F(Lo_LV_Drive)
ISC_545: C468.D9F(LV_Mon) C472.D9M(Lo_LV_Mon)
ISC_546: C468.D9F(Bias_HV_Mon) C472.D9M(Lo_Bias_Mon)
ISC_553: C472.D9F(Bias_Mon) ; port ISC_553
ISC_555: C473.D37M(3Lo) ; port ISC_555
ISC_556: C473.D37M(4Lo) ; port ISC_556
ISC_XB: C468.BNC(Length_Alt_Drive) C470.BNC
ISC_XC: C281.BNC C471.BNC
ISC_XE: C209.BNC(Length_Alt_Drive) C281.BNC
ISC_XF: C470.BNC C471.BNC
SUM_OUT_1: C214.TNC(PD_1) ; port SUM_OUT_1
NetC213_BNC: C213.BNC(Fast_Trigger) C281.BNC
NetC214_BNC: C214.BNC(Open_1) C471.BNC
NetC469_BNC: C469.BNC(Fast_Trigger) C470.BNC

Not connected (* = marked no-connect by the designer): C209 Conec-3(DC+/-18)* CPC(HV_Power)*; C213 Conec-3(DC+/-18)* CPC(HV_PWR)*; C214 Conec-3(+24VDC)* D9F(Shutter_1)*; C215 Conec-3(+24VDC)* RJ-11(X1)*; C468 Conec-3(DC+/-18)* CPC(HV_Power)*; C469 Conec-3(DC+/-18)* CPC(HV_PWR)*

### Layout directives
Length: X": ISC_538, ISC_539
Length: 5ft: ISC_555, ISC_556, SUM_OUT_1
Length: 20ft: ISC_234
Length: 12": ISC_529, ISC_530, ISC_531, ISC_532, ISC_535, ISC_542, ISC_543, ISC_544, ISC_545, ISC_546
Length: 25ft: ISC_409
Length: V?: ISC_525, ISC_526, ISC_527
Length: 2.5ft: ISC_510, ISC_511, ISC_516, ISC_517, ISC_540, ISC_541
Length: 1ft: ISC_512, ISC_513, ISC_518, ISC_519

### Notes on the sheet
- OMC A
- ISC-R5 Rack
- (near C469) Fast Shutter A
- OMC B
- (near C213) Fast Shutter B
- Fast Shutter Trigger
- ISC_Shutter_PZT_Readback_HAM6

### Library data of the parts
C207 = Aux. Conc. 1: Serial: Sxxxxxxx; System: ISC
C209 C468 = OMC Piezo Driver V2: Serial: Sxxxxxxx; System: ISC
C213 C469 = Fast Shutter Driver: Serial: Sxxxxxxx; System: ISC
C214 = Shutter Controller: Serial: Sxxxxxxx; System: ISC
C215 = Picomotor Driver: Serial: Sxxxxxxx; System: ISC
C281 C470 C471 = TNC Tee: Tee (TNC); Serial: Sxxxxxxx; System: ISC; Rack: ISCT?; Slot: U?
C472 = OMC PZT/Fast Shutter Panel: Serial: Sxxxxxxx; System: ISC
C473 C474 = Whitening Controls Concentrator: Serial: Sxxxxxxx; System: ISC

## Sheet ISCT1_SH1.SchDoc: ISC System Wiring Diagram
size B; DrawnBy: Filiberto Clara; Engineer: Filiberto Clara; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 22; SheetTotal: 37

### Parts
C_ISCT1_1  DCC: D1200811  Rack: ISCT1  Slot: U5-8  (hidden comment: Patch Panel Dual Frequency LSC RFPD)  (parts A,B,C,D,E of 5)
C_ISCT1_2  DCC: D1200810  Rack: ISCT1  Slot: U9-13  (hidden comment: Patch Panel Dual Frequency WFS RFPD)  (parts A,B,C,D,E,F,G,H,I,J of 10)
C_ISCT1_3  DCC: D1200810  Rack: ISCT1  Slot: U14-18  (hidden comment: Patch Panel Dual Frequency WFS RFPD)  (parts A,B,C,D,E,F,G,H,I,J of 10)
C_ISCT1_4  DCC: D1200811  Rack: ISCT1  Slot: U19-23  (hidden comment: Patch Panel Dual Frequency LSC RFPD)  (parts A,B,C,D,E of 5)

### Ports
ISC_31???, ISC_32??, ISC_219 (see ISC_R4_SH1[1D]), ISC_220 (see ISC_R4_SH1[1D]), ISCT1_1, ISCT1_2, ISCT1_3, ISCT1_4, ISCT1_5, ISCT1_6, ISCT1_7, ISCT1_8, ISCT1_9, ISCT1_10, ISCT1_11, ISCT1_12, ISCT1_13 (see ISCT1_SH2[1A]), ISCT1_14, ISCT1_15, ISCT1_16, ISCT1_17, ISCT1_18, ISCT1_19, ISCT1_20, ISCT1_21, ISCT1_22, ISCT1_24, ISCT1_25, ISCT1_26, ISCT1_28

### Nets
ISC_31???: C_ISCT1_2.D9F(Power) ; port ISC_31???
ISC_32??: C_ISCT1_3.D9F(Power) ; port ISC_32??
ISC_219: C_ISCT1_4.D9F(Power) ; port ISC_219
ISC_220: C_ISCT1_1.D9F(Power) ; port ISC_220
ISCT1_1: C_ISCT1_2.TNC(H3F) ; port ISCT1_1
ISCT1_2: C_ISCT1_4.TNC(TestIn) ; port ISCT1_2
ISCT1_3: C_ISCT1_3.TNC(LF3) ; port ISCT1_3
ISCT1_4: C_ISCT1_3.TNC(LF4) ; port ISCT1_4
ISCT1_5: C_ISCT1_3.TNC(LF1) ; port ISCT1_5
ISCT1_6: C_ISCT1_3.TNC(LF2) ; port ISCT1_6
ISCT1_7: C_ISCT1_3.TNC(HF4) ; port ISCT1_7
ISCT1_8: C_ISCT1_2.TNC(LF1) ; port ISCT1_8
ISCT1_9: C_ISCT1_3.TNC(H3F) ; port ISCT1_9
ISCT1_10: C_ISCT1_1.TNC(TestOut) ; port ISCT1_10
ISCT1_11: C_ISCT1_2.TNC(HF2) ; port ISCT1_11
ISCT1_12: C_ISCT1_3.TNC(HF2) ; port ISCT1_12
ISCT1_13: C_ISCT1_2.TNC(LF4) ; port ISCT1_13
ISCT1_14: C_ISCT1_3.TNC(HF1) ; port ISCT1_14
ISCT1_15: C_ISCT1_4.TNC(RFHI) ; port ISCT1_15
ISCT1_16: C_ISCT1_2.TNC(LF2) ; port ISCT1_16
ISCT1_17: C_ISCT1_4.TNC(TestOut) ; port ISCT1_17
ISCT1_18: C_ISCT1_2.TNC(LF3) ; port ISCT1_18
ISCT1_19: C_ISCT1_2.TNC(HF1) ; port ISCT1_19
ISCT1_20: C_ISCT1_1.TNC(TestIn) ; port ISCT1_20
ISCT1_21: C_ISCT1_1.TNC(RFHI) ; port ISCT1_21
ISCT1_22: C_ISCT1_4.TNC(RFLO) ; port ISCT1_22
ISCT1_24: C_ISCT1_2.TNC(HF4) ; port ISCT1_24
ISCT1_25: C_ISCT1_2.TNC(Test) ; port ISCT1_25
ISCT1_26: C_ISCT1_3.TNC(Test) ; port ISCT1_26
ISCT1_28: C_ISCT1_1.TNC(RFLO) ; port ISCT1_28

Not connected (* = marked no-connect by the designer): C_ISCT1_1 D9M(Power)*; C_ISCT1_2 D9M(Power)*; C_ISCT1_3 D9M(Power)*; C_ISCT1_4 D9M(Power)*

### Notes on the sheet
- ISCT1 - Right Side
- Inside Enclosure
- LSC RFPD REFL Air A
- ASC WFS REFL Air B
- ASC WFS REFL Air A
- Cable labeled ISC_31, but label already used.
- LSC RFPD POP Air A

### Library data of the parts
C_ISCT1_1 C_ISCT1_4 = Patch Panel Dual Frequency LSC RFPD: Patch Panel (D1200811); Serial: Sxxxxxxx; System: ISC
C_ISCT1_2 C_ISCT1_3 = Patch Panel Dual Frequency WFS RFPD: Patch Panel (D1200810); Serial: Sxxxxxxx; System: ISC

## Sheet ISCT1_SH2.SchDoc: ISC System Wiring Diagram
size B; DrawnBy: Filiberto Clara; Engineer: Filiberto Clara; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 23; SheetTotal: 37

### Parts
C_ISCT1_5  DCC: D1200889  Rack: ISCT1  Slot: U23  (hidden comment: Patch Panel Broadband PD)  (parts A,B of 2)
C_ISCT1_6  DCC: D1101072  Rack: ISCT1  Slot: U24-25  (hidden comment: Patch Panel DCPD Interface)  (parts A,B of 2)
C_ISCT1_7  DCC: D1102369  Rack: ISCT1  Slot: U26-27  (hidden comment: Patch Panel Uniblitz Shutters)  (parts A,B of 2)
C_ISCT1_8  DCC: D1200889  Rack: ISCT1  Slot: U28  (hidden comment: Patch Panel Broadband PD)  (parts A,B of 2)
C_ISCT1_9  DCC: D1201399  Rack: ISCT1  Slot: U29-31  (hidden comment: Patch Panel DCPD)  (parts A,B,C,D,E,F of 6)
C_ISCT1_10  DCC: D1201483  Rack: ISCT1  Slot: U32  (hidden comment: Patch Panel TEC Driver)
C_ISCT1_11  DCC: D1102369  Rack: ISCT1  Slot: U37-38  (hidden comment: Patch Panel Uniblitz Shutters)  (parts A,B of 2)
C_ISCT1_12  DCC: D1102333  Rack: ISCT1  Slot: U39-42  (hidden comment: Patch Panel Analog Video)  (parts A,B,C,D,E of 5)

### Ports
IOT1_Video_POD, IOT1_Video_Refl, IOT1_Video_Refl_PD, ISC_259???, ISC_331 (see ISC_C2_SH2[4D]), ISCT1_13 (see ISCT1_SH1[1B]), ISCT1_23, ISCT1_ACC_Y, ISCT1_DB9_1, ISCT1_DB9_2, ISCT1_DB9_3, ISCT1_DB9_4, ISCT1_XX (see ISCT1_SH2[1B]), ISCT1_XX (see ISCT1_SH2[1C]), R4_ISCT1_1, R4_ISCT1_2, XX

### Nets
IOT1_Video_POD: C_ISCT1_12.BNC(CH_3) ; port IOT1_Video_POD
IOT1_Video_Refl: C_ISCT1_12.BNC(CH_2) ; port IOT1_Video_Refl
IOT1_Video_Refl_PD: C_ISCT1_12.BNC(CH_4)
ISC_259???: C_ISCT1_6.D9F(Output) ; port ISC_259???
ISC_331: C_ISCT1_10.D15M(TEC) ; port ISC_331
ISCT1_13: C_ISCT1_5.TNC(RF1) ; port ISCT1_13
ISCT1_23: C_ISCT1_5.TNC(RF2) ; port ISCT1_23
ISCT1_ACC_Y: C_ISCT1_12.BNC(CH_1) ; port ISCT1_ACC_Y
ISCT1_DB9_1: C_ISCT1_7.D9M(Output) ; port ISCT1_DB9_1
ISCT1_DB9_2: C_ISCT1_7.D9M(B) ; port ISCT1_DB9_2
ISCT1_DB9_3: C_ISCT1_11.D9M(Output) ; port ISCT1_DB9_3
ISCT1_DB9_4: C_ISCT1_11.D9M(B) ; port ISCT1_DB9_4
ISCT1_XX: C_ISCT1_8.TNC(RF1) ; port ISCT1_XX
R4_ISCT1_1: C_ISCT1_9.TNC ; port R4_ISCT1_1
R4_ISCT1_2: C_ISCT1_9.TNC ; port R4_ISCT1_2
XX: C_ISCT1_12.3W3(Power) ; port XX

Not connected (* = marked no-connect by the designer): C_ISCT1_6 3W3(DC±17)* D9M(Output)*; C_ISCT1_7 D9F(Output)*; C_ISCT1_10 D15F(TEC)*; C_ISCT1_11 D9F(Output)*

### Notes on the sheet
- ISCT1 - Right Side
- Inside Enclosure
- labeled ISC_259, but label already used.
- ±18V from SUS-R1
- Gray cable, label 29. Need to relabel.
- Gray cable, label 30 Need to relabel.
- No Cable

### Library data of the parts
C_ISCT1_5 C_ISCT1_8 = Patch Panel Broadband PD: Patch Panel (D1200889); Serial: Sxxxxxxx; System: ISC
C_ISCT1_6 = Patch Panel DCPD Interface: Patch Panel (D1101072); Serial: Sxxxxxxx; System: ISC
C_ISCT1_7 C_ISCT1_11 = Patch Panel Uniblitz Shutters: Patch Panel (D1102369); Serial: Sxxxxxxx; System: ISC
C_ISCT1_9 = Patch Panel DCPD: Patch Panel (D1201399); Serial: Sxxxxxxx; System: ISC
C_ISCT1_10 = Patch Panel TEC Driver: Patch Panel (D1201483); Serial: Sxxxxxxx; System: ISC
C_ISCT1_12 = Patch Panel Analog Video: Patch Panel (D1102333); Serial: Sxxxxxxx; System: ISC

## Sheet IOT2_SH1.SchDoc: ISC System Wiring Diagram
size B; DrawnBy: Filiberto Clara; Engineer: Filiberto Clara; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 24; SheetTotal: 37

### Parts
C_IOT2_1  DCC: D1102333  Rack: IOT2  Slot: U19-22  (hidden comment: Patch Panel Analog Video)  (parts A,B,C,D,E of 5)
C_IOT2_2  DCC: D1200889  Rack: IOT2  Slot: U23  (hidden comment: Patch Panel Broadband PD)  (parts A,B of 2)
C_IOT2_3  DCC: D1200812  Rack: IOT2  Slot: U24-27  (hidden comment: Patch Panel Single Frequency WFS RFPD)  (parts A,B,C,D,E of 5)
C_IOT2_4  DCC: D1200812  Rack: IOT2  Slot: U28-31  (hidden comment: Patch Panel Single Frequency WFS RFPD)  (parts A,B,C,D,E of 5)
C_IOT2_5  DCC: D1101072  Rack: IOT2  Slot: U32-33  (hidden comment: Patch Panel DCPD Interface)  (parts A,B of 2)
C_IOT2_6  DCC: D1200811  Rack: IOT2  Slot: U34-37  (hidden comment: Patch Panel Dual Frequency LSC RFPD)  (parts A,B,C,D,E of 5)
C_IOT2_7  DCC: D1201540  Rack: IOT2  Slot: U38-41  (hidden comment: Patch Panel Interlocks/Lighting)  (parts A,B,C,D,E of 5)

### Ports
ISC_16???, ISC_24 (see ISC_R1_SH2[4D]), ISC_25 (see ISC_R1_SH2[4D]), ISC_270 (see ISC_C1_SH1[1B]), ISC_R1_Spare, ISC_RF4-1B, ISC_RF8-2B (see ISC_R1_SH3[1C]), ISC_RF8-3B (see ISC_R1_SH3[1C]), ISC_RF8-4B (see ISC_R1_SH3[1C]), ISC_RF8-5B (see ISC_R1_SH3[1C]), ISC_RF8-6B (see ISC_R1_SH3[1C]), ISC_RF8-7B (see ISC_R1_SH3[1C]), ISC_RF8-8B (see ISC_R1_SH3[1C]), ISC_RF8-B1, ISC_Trigger_PD, ISC_X6, ISC_X7, ISC_X8, ISC_X9, Safety_IOT2_1, Safety_IOT2_2, Safety_IOT2_Power

### Nets
ISC_16???: C_IOT2_6.D9F(Power) ; port ISC_16???
ISC_24: C_IOT2_4.D9F(Power) ; port ISC_24
ISC_25: C_IOT2_3.D9F(Power) ; port ISC_25
ISC_270: C_IOT2_5.D9F(Output) ; port ISC_270
ISC_R1_Spare: C_IOT2_6.TNC(TestIn) ; port ISC_R1_Spare
ISC_RF4-1B: C_IOT2_6.TNC(RFHI) ; port ISC_RF4-1B
ISC_RF8-2B: C_IOT2_4.TNC(RFLO) ; port ISC_RF8-2B
ISC_RF8-3B: C_IOT2_4.TNC(TestIn) ; port ISC_RF8-3B
ISC_RF8-4B: C_IOT2_4.TNC(TestOut) ; port ISC_RF8-4B
ISC_RF8-5B: C_IOT2_3.TNC(RFHI) ; port ISC_RF8-5B
ISC_RF8-6B: C_IOT2_3.TNC(RFLO) ; port ISC_RF8-6B
ISC_RF8-7B: C_IOT2_3.TNC(TestIn) ; port ISC_RF8-7B
ISC_RF8-8B: C_IOT2_3.TNC(TestOut) ; port ISC_RF8-8B
ISC_RF8-B1: C_IOT2_4.TNC(RFHI) ; port ISC_RF8-B1
ISC_Trigger_PD: C_IOT2_2.TNC(RF1) ; port ISC_Trigger_PD
ISC_X6: C_IOT2_5.3W3(DC±17) ; port ISC_X6
ISC_X7: C_IOT2_1.BNC(CH_1) ; port ISC_X7
ISC_X8: C_IOT2_1.BNC(CH_2) ; port ISC_X8
ISC_X9: C_IOT2_1.BNC(CH_3) ; port ISC_X9
Safety_IOT2_1: C_IOT2_7.M12(CH_1) ; port Safety_IOT2_1
Safety_IOT2_2: C_IOT2_7.M12(CH_2) ; port Safety_IOT2_2
Safety_IOT2_Power: C_IOT2_7.3W3(Power) ; port Safety_IOT2_Power

Not connected (* = marked no-connect by the designer): C_IOT2_1 3W3(Power)*; C_IOT2_3 D9M(Power)*; C_IOT2_4 D9M(Power)*; C_IOT2_5 D9M(Output)*; C_IOT2_6 D9M(Power)*

### Layout directives
Length: 50ft: ISC_RF8-5B

### Notes on the sheet
- IOT2 - Left Side
- No Cable
- Cable labeled ISC_16, but label already used.

### Library data of the parts
C_IOT2_1 = Patch Panel Analog Video: as C_ISCT1_12 on sheet ISCT1_SH2
C_IOT2_2 = Patch Panel Broadband PD: as C_ISCT1_5 on sheet ISCT1_SH2
C_IOT2_3 C_IOT2_4 = Patch Panel Single Frequency WFS RFPD: Patch Panel (D1200812); Serial: Sxxxxxxx; System: ISC
C_IOT2_5 = Patch Panel DCPD Interface: as C_ISCT1_6 on sheet ISCT1_SH2
C_IOT2_6 = Patch Panel Dual Frequency LSC RFPD: as C_ISCT1_1 on sheet ISCT1_SH1
C_IOT2_7 = Patch Panel Interlocks/Lighting: Patch Panel Interlocks/Lighting (D1201540); Serial: Sxxxxxxx; System: ISC

## Sheet IOT2_SH2.SchDoc: ISC System Wiring Diagram
size B; DrawnBy: Filiberto Clara; Engineer: Filiberto Clara; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 25; SheetTotal: 37

### Parts
C_IOT2_8  Picomotor Driver  DCC: D1100323  Rack: IOT2  Slot: Top - Left Side
C_IOT2_9  Picomotor Driver  DCC: D1100323  Rack: IOT2  Slot: Top - Left Side
C_IOT2_10  Picomotor Driver  DCC: D1100323  Rack: IOT2  Slot: Top - Left Side
C_IOT2_11  DCC: D1101691  Rack: IOT2  Slot: U?  (hidden comment: Patch Panel Picomotor Breakout)
C_IOT2_12  Shutter Controller  DCC: D1102312  Rack: IOT2  Slot: Top - Left Side
C_IOT2_13  DCC: D1102369  Rack: IOT2  Slot: U?  (hidden comment: Patch Panel Uniblitz Shutters)  (parts A,B of 2)

### Ports
ISC_178 (see ISC_C2_SH2[4B]), ISC_179 (see ISC_C2_SH2[4A]), ISC_180 (see ISC_C2_SH2[4B]), ISC_181 (see ISC_C2_SH2[4B]), ISC_227, ISC_230, ISC_243, ISC_292, ISC_293, ISC_294 (see ISC_C2_SH2[2C]), ISC_303 (see ISC_C2_SH2[4B]), ISC_304 (see ISC_C2_SH2[4B]), PSL_ISS_PM5

### Nets
ISC_178: C_IOT2_8.D25F(Readbacks) ; port ISC_178
ISC_179: C_IOT2_8.D25M(Controls) ; port ISC_179
ISC_180: C_IOT2_9.D25F(Readbacks) ; port ISC_180
ISC_181: C_IOT2_9.D25M(Controls) ; port ISC_181
ISC_227: C_IOT2_8.D25F(Chan_1-4_Outputs) ; port ISC_227
ISC_230: C_IOT2_8.D25F(Chan_5-8_Outputs) ; port ISC_230
ISC_243: C_IOT2_10.D25F(Chan_1-4_Outputs) ; port ISC_243
ISC_292: C_IOT2_9.D25F(Chan_5-8_Outputs) ; port ISC_292
ISC_293: C_IOT2_9.D25F(Chan_1-4_Outputs) ; port ISC_293
ISC_294: C_IOT2_12.D15F(Controls) ; port ISC_294
ISC_303: C_IOT2_10.D25F(Readbacks) ; port ISC_303
ISC_304: C_IOT2_10.D25M(Controls) ; port ISC_304
ISC_IOT2_Shutter: C_IOT2_12.D9F(Shutter_1) C_IOT2_13.D9M(Output)
PSL_ISS_PM5: C_IOT2_10.D25F(Chan_5-8_Outputs) ; port PSL_ISS_PM5

Not connected (* = marked no-connect by the designer): C_IOT2_8 Conec-3(+24VDC)* RJ-11(X1)*; C_IOT2_9 Conec-3(+24VDC)* RJ-11(X1)*; C_IOT2_10 Conec-3(+24VDC)* RJ-11(X1)*; C_IOT2_11 D9F(2)* D25M(Pico); C_IOT2_12 BNC(Open_1)* Conec-3(+24VDC)* TNC(PD_1)*; C_IOT2_13 D9F(Output)*

### Notes on the sheet
- PICO MOTOR 3
- PICO MOTOR 4
- PICO MOTOR 5

### Library data of the parts
C_IOT2_8-C_IOT2_10 = Picomotor Driver: Serial: Sxxxxxxx; System: ISC
C_IOT2_11 = Patch Panel Picomotor Breakout: Patch Panel (D1101691); Serial: Sxxxxxxx; System: ISC
C_IOT2_12 = Shutter Controller: Serial: Sxxxxxxx; System: ISC
C_IOT2_13 = Patch Panel Uniblitz Shutters: as C_ISCT1_7 on sheet ISCT1_SH2

## Sheet HAM6_SH1.SchDoc: ISC System Wiring Diagram
size B; DrawnBy: Filiberto Clara; Engineer: Filiberto Clara; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 26; SheetTotal: 37

### Parts
C_HAM6_C1-1C1  D25 Vacuum Feedthrough  Rack: HAM6  Slot: C1-1C1
C_HAM6_C1-6D1  MIL Vacuum Feedthrough  Rack: HAM6  Slot: C1-6D1
C_HAM6_D3-2C1  D25 Vacuum Feedthrough  DCC: D1300467  Rack: HAM6  Slot: D3-2C1
C_HAM6_D3-2C2  D25 Vacuum Feedthrough  DCC: D1300467  Rack: HAM6  Slot: D3-2C2
C_HAM6_D5-2D1  Accuglass 25D-5CX2-450  DCC: D1300467  Rack: R?  Slot: D5-2D1
C_HAM6_D5-2D2  Accuglass 25D-5CX2-450  DCC: D1300467  Rack: R?  Slot: D5-2D2
C_HAM6_D5-3D1  Accuglass 25D-5CX2-450  DCC: D1300467  Rack: R?  Slot: D5-3D1
C_HAM6_D5-3D2  Accuglass 25D-5CX2-450  DCC: D1300467  Rack: R?  Slot: D5-3D2
C_HAM6_D6-F6  D25 Vacuum Feedthrough  Rack: HAM6  Slot: D6-F6
C_HAM6_D6-F7  D25 Vacuum Feedthrough  Rack: HAM6  Slot: D6-F7
C_HAM6_D6-F8  D25 Vacuum Feedthrough  Rack: HAM6  Slot: D6-F8
C_HAM6_D6-F9  D25 Vacuum Feedthrough  Rack: HAM6  Slot: D6-F9
C_HAM6_D6-F10  D25 Vacuum Feedthrough  Rack: HAM6  Slot: D6-F10
C_HAM6_D6-F12  D25 Vacuum Feedthrough  Rack: HAM6  Slot: D6-F12
C_HAM_C1-7D1  MIL Vacuum Feedthrough  Rack: HAM6  Slot: C1-7D1
C_HAM_D6-F11  D25 Vacuum Feedthrough  Rack: HAM6  Slot: D6-F11

### Ports
ISC_232 (see ISC_R5_SH1[1D]), ISC_233 (see ISC_R5_SH1[1C]), ISC_234 (see ISC_R5_SH3[3C]), ISC_265 (see ISC_R5_SH1[1B]), ISC_266 (see ISC_R5_SH1[1B]), ISC_307 (see ISC_R5_SH2[1C]), ISC_404 (see ISC_R5_SH1[1C]), ISC_409 (see ISC_R5_SH3[3A]), ISC_520 (see ISC_R5_SH2[1D]), ISC_525 (see ISC_R5_SH3[3B]), ISC_526 (see ISC_R5_SH3[3A]), ISC_527 (see ISC_R5_SH3[3B]), ISC_R26-B/1 (see ISC_R3_SH2[1A]), ISC_R26-B/2 (see ISC_R3_SH2[1A]), ISC_R26-B/3 (see ISC_R3_SH2[1B]), ISC_R26-B/4 (see ISC_R3_SH2[1A]), ISC_R26-B/5 (see ISC_R3_SH2[1B]), ISC_R27-B/1 (see ISC_R3_SH2[1B]), ISC_R27-B/2 (see ISC_R3_SH2[1A]), ISC_R27-B/3 (see ISC_R3_SH2[1B]), ISC_R27-B/4 (see ISC_R3_SH2[1A]), ISC_R27-B/5 (see ISC_R3_SH2[1B]), ISC_RF28-B/1 (see ISC_R3_SH2[1C]), ISC_RF28-B/2 (see ISC_R3_SH2[1C]), ISC_RF28-B/3 (see ISC_R3_SH2[1D]), ISC_RF28-B/4 (see ISC_R3_SH2[1C]), ISC_RF28-B/5 (see ISC_R3_SH2[1D]), ISC_RF29-B/1 (see ISC_R3_SH2[1D]), ISC_RF29-B/2 (see ISC_R3_SH2[1C]), ISC_RF29-B/3 (see ISC_R3_SH2[1D]), ISC_RF29-B/4 (see ISC_R3_SH2[1C]), ISC_RF29-B/5 (see ISC_R3_SH2[1D])

### Nets
ISC_232: C_HAM6_D6-F9.D25M(Vac._Side) ; port ISC_232
ISC_233: C_HAM6_D6-F12.D25M(Vac._Side) ; port ISC_233
ISC_234: C_HAM6_C1-1C1.D25M(Vac._Side) ; port ISC_234
ISC_265: C_HAM6_D3-2C1.D25M(Vac._Side) ; port ISC_265
ISC_266: C_HAM6_D3-2C2.D25M(Vac._Side) ; port ISC_266
ISC_307: C_HAM6_D6-F7.D25M(Vac._Side) ; port ISC_307
ISC_404: C_HAM6_D6-F6.D25M(Vac._Side) ; port ISC_404
ISC_409: C_HAM6_D6-F8.D25M(Vac._Side) ; port ISC_409
ISC_520: C_HAM6_D6-F10.D25M(Vac._Side) ; port ISC_520
ISC_525: C_HAM_D6-F11.D25M(Vac._Side) ; port ISC_525
ISC_526: C_HAM6_C1-6D1.MIL(Vac._Side) ; port ISC_526
ISC_527: C_HAM_C1-7D1.MIL(Vac._Side) ; port ISC_527
ISC_R26-B/1: C_HAM6_D5-2D2.coax(V1) ; port ISC_R26-B/1
ISC_R26-B/2: C_HAM6_D5-2D2.coax(A2) ; port ISC_R26-B/2
ISC_R26-B/3: C_HAM6_D5-2D2.coax(A3) ; port ISC_R26-B/3
ISC_R26-B/4: C_HAM6_D5-2D2.coax(A4) ; port ISC_R26-B/4
ISC_R26-B/5: C_HAM6_D5-2D2.coax(A5) ; port ISC_R26-B/5
ISC_R27-B/1: C_HAM6_D5-2D1.coax(V1) ; port ISC_R27-B/1
ISC_R27-B/2: C_HAM6_D5-2D1.coax(A2) ; port ISC_R27-B/2
ISC_R27-B/3: C_HAM6_D5-2D1.coax(A3) ; port ISC_R27-B/3
ISC_R27-B/4: C_HAM6_D5-2D1.coax(A4) ; port ISC_R27-B/4
ISC_R27-B/5: C_HAM6_D5-2D1.coax(A5) ; port ISC_R27-B/5
ISC_RF28-B/1: C_HAM6_D5-3D2.coax(V1) ; port ISC_RF28-B/1
ISC_RF28-B/2: C_HAM6_D5-3D2.coax(A2) ; port ISC_RF28-B/2
ISC_RF28-B/3: C_HAM6_D5-3D2.coax(A3) ; port ISC_RF28-B/3
ISC_RF28-B/4: C_HAM6_D5-3D2.coax(A4) ; port ISC_RF28-B/4
ISC_RF28-B/5: C_HAM6_D5-3D2.coax(A5) ; port ISC_RF28-B/5
ISC_RF29-B/1: C_HAM6_D5-3D1.coax(V1) ; port ISC_RF29-B/1
ISC_RF29-B/2: C_HAM6_D5-3D1.coax(A2) ; port ISC_RF29-B/2
ISC_RF29-B/3: C_HAM6_D5-3D1.coax(A3) ; port ISC_RF29-B/3
ISC_RF29-B/4: C_HAM6_D5-3D1.coax(A4) ; port ISC_RF29-B/4
ISC_RF29-B/5: C_HAM6_D5-3D1.coax(A5) ; port ISC_RF29-B/5

### Layout directives
DCC: D1300467-v4: ISC_265, ISC_266, ISC_R26-B/5, ISC_R27-B/5, ISC_RF28-B/5, ISC_RF29-B/5
DCC: D2400268: ISC_232, ISC_233, ISC_234, ISC_307, ISC_404, ISC_520
DCC: D1300589: ISC_409, ISC_525
DCC: D1400225: ISC_526, ISC_527

### Notes on the sheet
- HAM6 Flange Layout
- DCPD A/B
- AS_A WFS DC
- DCPD C/D
- OMC A PZTs
- AS_B WFS DC
- AS_A WFS 36/45MHz
- OMC B PZTs
- OMC A/B QPD
- OMC C/D QPD
- AS_C/LO_C QPD
- AS_B WFS 36/45MHz
- Picomotor
- Fast Shutter 1
- Fast Shutter 2

### Library data of the parts
C_HAM6_C1-1C1 C_HAM6_C1-6D1 C_HAM6_D3-2C1 C_HAM6_D3-2C2 C_HAM6_D6-F6-C_HAM6_D6-F10 C_HAM6_D6-F12 C_HAM_C1-7D1 C_HAM_D6-F11 = VacFeedD25: Serial: Sxxxxxxx; System: ISC
C_HAM6_D5-2D1 C_HAM6_D5-2D2 C_HAM6_D5-3D1 C_HAM6_D5-3D2 = Vac.Feed Coax DB 5W5: Vac.Feed Coax Dsub DB5W5; System: ISC

## Sheet HAM6_SH2.SchDoc: ISC System Wiring Diagram
size B; DrawnBy: Filiberto Clara; Engineer: Filiberto Clara; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 27; SheetTotal: 37

### Parts
C_HAM6_D3-2D1  Accuglass 25D-5CX2-450  DCC: D1300467  Rack: HAM6  Slot: D3-2D1
C_HAM6_D3-2D2  Accuglass 25D-5CX2-450  DCC: D1300467  Rack: HAM6  Slot: D3-2D2
C_HAM6_D3-3D1  Accuglass 25D-5CX2-450  DCC: D1300467  Rack: HAM6  Slot: D3-3D1
C_HAM6_D3-3D2  Accuglass 25D-5CX2-450  DCC: D1300467  Rack: HAM6  Slot: D3-3D2
C_HAM_D3-1C1  D25 Vacuum Feedthrough  DCC: D1300467  Rack: HAM6  Slot: D3-1C1
C_HAM_D3-1C2  D25 Vacuum Feedthrough  DCC: D1300467  Rack: HAM6  Slot: D3-1C2
C_HAM_D4-2A  Vac.Feed SMA  Rack: HAM6  Slot: D4-2A
C_HAM_D4-3A  Vac.Feed SMA  Rack: HAM6  Slot: D4-3A
C_HAM_D5-1C3  D25 Vacuum Feedthrough  Rack: HAM6  Slot: D5-1C3
C_HAM_D5-1D1  Accuglass 25D-5CX2-450  DCC: D1300467  Rack: HAM6  Slot: D5-1D1

### Ports
ISC_439 (see ISC_R5_SH2[1A]), ISC_440 (see ISC_R5_SH2[1A]), ISC_441 (see ISC_R5_SH2[1A]), ISC_442 (see ISC_R5_SH2[1A]), ISC_514 (see ISC_R5_SH1[1B]), ISC_515 (see ISC_R5_SH1[1B]), ISC_552 (see ISC_R5_SH2[4A]), ISC_RF40-B/1 (see ISC_R3_SH2[1B]), ISC_RF40-B/2 (see ISC_R3_SH2[1B]), ISC_RF40-B/3 (see ISC_R5_SH1[1A]), ISC_RF40-B/4 (see ISC_R3_SH2[1B]), ISC_RF40-B/5 (see ISC_R5_SH1[1A]), ISC_RF41-B/1 (see ISC_R5_SH1[1A]), ISC_RF41-B/2 (see ISC_R3_SH2[1B]), ISC_RF41-B/3 (see ISC_R5_SH1[1A]), ISC_RF41-B/4 (see ISC_R3_SH2[1B]), ISC_RF41-B/5 (see ISC_R5_SH1[1A]), ISC_RF42-B/1 (see ISC_R3_SH2[1C]), ISC_RF42-B/2 (see ISC_R3_SH2[1C]), ISC_RF42-B/3 (see ISC_R5_SH1[1A]), ISC_RF42-B/4 (see ISC_R3_SH2[1C]), ISC_RF42-B/5 (see ISC_R5_SH1[1A]), ISC_RF43-B/1 (see ISC_R5_SH1[1A]), ISC_RF43-B/2 (see ISC_R3_SH2[1C]), ISC_RF43-B/3 (see ISC_R5_SH1[1A]), ISC_RF43-B/4 (see ISC_R3_SH2[1C]), ISC_RF43-B/5 (see ISC_R5_SH1[1A]), ISC_RF44-B/1 (see ISC_R5_SH2[1B]), ISC_RF44-B/2 (see ISC_R5_SH2[1B]), ISC_RF44-B/3 (see ISC_R5_SH2[1B]), ISC_RF44-B/4 (see ISC_R5_SH2[1B]), ISC_RF44-B/5 (see ISC_R5_SH2[1B])

### Nets
ISC_439: C_HAM_D4-2A.SMA(A1) ; port ISC_439
ISC_440: C_HAM_D4-2A.SMA(A2) ; port ISC_440
ISC_441: C_HAM_D4-3A.SMA(A1) ; port ISC_441
ISC_442: C_HAM_D4-3A.SMA(A2) ; port ISC_442
ISC_514: C_HAM_D3-1C1.D25M(Vac._Side) ; port ISC_514
ISC_515: C_HAM_D3-1C2.D25M(Vac._Side) ; port ISC_515
ISC_552: C_HAM_D5-1C3.D25M(Vac._Side) ; port ISC_552
ISC_RF40-B/1: C_HAM6_D3-2D2.coax(V1) ; port ISC_RF40-B/1
ISC_RF40-B/2: C_HAM6_D3-2D2.coax(A2) ; port ISC_RF40-B/2
ISC_RF40-B/3: C_HAM6_D3-2D2.coax(A3) ; port ISC_RF40-B/3
ISC_RF40-B/4: C_HAM6_D3-2D2.coax(A4) ; port ISC_RF40-B/4
ISC_RF40-B/5: C_HAM6_D3-2D2.coax(A5) ; port ISC_RF40-B/5
ISC_RF41-B/1: C_HAM6_D3-2D1.coax(V1) ; port ISC_RF41-B/1
ISC_RF41-B/2: C_HAM6_D3-2D1.coax(A2) ; port ISC_RF41-B/2
ISC_RF41-B/3: C_HAM6_D3-2D1.coax(A3) ; port ISC_RF41-B/3
ISC_RF41-B/4: C_HAM6_D3-2D1.coax(A4) ; port ISC_RF41-B/4
ISC_RF41-B/5: C_HAM6_D3-2D1.coax(A5) ; port ISC_RF41-B/5
ISC_RF42-B/1: C_HAM6_D3-3D2.coax(V1) ; port ISC_RF42-B/1
ISC_RF42-B/2: C_HAM6_D3-3D2.coax(A2) ; port ISC_RF42-B/2
ISC_RF42-B/3: C_HAM6_D3-3D2.coax(A3) ; port ISC_RF42-B/3
ISC_RF42-B/4: C_HAM6_D3-3D2.coax(A4) ; port ISC_RF42-B/4
ISC_RF42-B/5: C_HAM6_D3-3D2.coax(A5) ; port ISC_RF42-B/5
ISC_RF43-B/1: C_HAM6_D3-3D1.coax(V1) ; port ISC_RF43-B/1
ISC_RF43-B/2: C_HAM6_D3-3D1.coax(A2) ; port ISC_RF43-B/2
ISC_RF43-B/3: C_HAM6_D3-3D1.coax(A3) ; port ISC_RF43-B/3
ISC_RF43-B/4: C_HAM6_D3-3D1.coax(A4) ; port ISC_RF43-B/4
ISC_RF43-B/5: C_HAM6_D3-3D1.coax(A5) ; port ISC_RF43-B/5
ISC_RF44-B/1: C_HAM_D5-1D1.coax(V1) ; port ISC_RF44-B/1
ISC_RF44-B/2: C_HAM_D5-1D1.coax(A2) ; port ISC_RF44-B/2
ISC_RF44-B/3: C_HAM_D5-1D1.coax(A3) ; port ISC_RF44-B/3
ISC_RF44-B/4: C_HAM_D5-1D1.coax(A4) ; port ISC_RF44-B/4
ISC_RF44-B/5: C_HAM_D5-1D1.coax(A5) ; port ISC_RF44-B/5

### Layout directives
DCC: D1300467-v4: ISC_514, ISC_515, ISC_RF40-B/5, ISC_RF41-B/5, ISC_RF42-B/5, ISC_RF43-B/5
DCC: D1300466-v4: ISC_552, ISC_RF44-B/5

### Notes on the sheet
- HAM6 Flange Layout
- OMC_REFL DC
- LO_A WFS DC
- OMC_REFL_A
- LO_B WFS DC
- LO_A WFS 36/45MHz
- DCPD 3.1MHz A/B
- DCPD 3.1MHz C/D
- LO_B WFS 36/45MHz

### Library data of the parts
C_HAM6_D3-2D1 C_HAM6_D3-2D2 C_HAM6_D3-3D1 C_HAM6_D3-3D2 C_HAM_D5-1D1 = Vac.Feed Coax DB 5W5: Vac.Feed Coax Dsub DB5W5; System: ISC
C_HAM_D3-1C1 C_HAM_D3-1C2 C_HAM_D5-1C3 = VacFeedD25: Serial: Sxxxxxxx; System: ISC
C_HAM_D4-2A C_HAM_D4-3A = Vac.Feed SMA: Vac.Feed coax SMA; Serial: Sxxxxxxx; System: ISC

## Sheet SqueezerWfsWiring.SchDoc: Squeezer Wavefront Sensing
size B; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 28; SheetTotal: 37; DrawnBy: R.  Abbott; Engineer: R.  Abbott; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.09¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=7¦PrintQuality=-4¦MediaType=1¦DitherType=10¦PaperKind=11x17¦PrintScaleMode=1

### Parts
C267  105kHz ADC Interface Chassis  DCC: D2000552  Rack: SQZ-R1  Slot: U4
C381  105kHz QPD Head Vac.  DCC: D2000246  Rack: HAM7 ISI  Slot: QPD A
C383  D25 Vacuum Feedthrough  Rack: HAM7  Slot: D8-F1
C384  D25 Vacuum Feedthrough  Rack: HAM7  Slot: D8-F2
C385  105kHz QPD Head Vac.  DCC: D2000246  Rack: HAM7 ISI  Slot: QPD B

### Ports
__Ties to Beckhoff, FC QPDs (see SqueezerBeckhoff2[3C]), ISC_SQ_472 (see SqueezerRfControls1[3B]), ISC_SQ_473 (see SqueezerRfControls1[3B]), ISC_SQ_474 (see SqueezerRfControls1[3B]), ISC_SQ_475 (see SqueezerRfControls1[3B]), ISC_SQ_476 (see ISC_C1_SH2[5C]), ISC_SQ_478 (see SqueezerRfControls2[6A]), ISC_SQ_525 (see SqueezerConcentrators[1C]), Ties to_RF Distribution

### Nets
ISC_SQ_472: C267.TNC(OMC_I) ; port ISC_SQ_472
ISC_SQ_473: C267.TNC(OMC_Q) ; port ISC_SQ_473
ISC_SQ_474: C267.TNC(HD_I) ; port ISC_SQ_474
ISC_SQ_475: C267.TNC(HD_Q) ; port ISC_SQ_475
ISC_SQ_476: C267.D37F(ADC) ; port ISC_SQ_476
ISC_SQ_477: C267.D25F(Beckhoff) ; port FC QPDs
ISC_SQ_478: C267.DB9M(RFL_PLL) ; port ISC_SQ_478
ISC_SQ_479: C267.D25F(WFS_1) C383.D25M(Air_Side)
ISC_SQ_480: C267.D25F(WFS_2) C384.D25M(Air_Side)
ISC_SQ_525: C267.TNC(Spare_3) ; port ISC_SQ_525
VAC_SQ_001: C381.D25M(Interface) C383.D25M(Vac._Side)
VAC_SQ_002: C384.D25M(Vac._Side) C385.D25M(Interface)

Not connected (* = marked no-connect by the designer): C267 Conec-3(DC±17)*

### Layout directives
Length: 70ft: ISC_SQ_479, ISC_SQ_480
DCC: D1000225: VAC_SQ_001, VAC_SQ_002
Length: ft: VAC_SQ_001, VAC_SQ_002
Length: 45": ISC_SQ_472, ISC_SQ_473, ISC_SQ_474, ISC_SQ_475
Length: 6ft: ISC_SQ_525

### Notes on the sheet
- SQZ-FC_QPD_A
- SQZ-FC_QPD_B
- Key
- Dot Identifies Cable Shield Terminating to Backshell
- Pin With Triangle Indicates Pin on Rear or the Like
- Pin With No Triangle Indicates Pin on Front or the Like
- Light Blue Symbols Are In-Vacuum
- Yellow Symbols Are In-Air

### Library data of the parts
C267 = 105kHz ADC Interface Chassis: Serial: Sxxxxxxx; System: ISC
C381 C385 = 105kHz QPD Head Vac.: Serial: Sxxxxxxx; System: ISC
C383 C384 = VacFeedD25: Serial: Sxxxxxxx; System: ISC

## Sheet SqueezerInVacControls.SchDoc: Squeezer In-Vacuum Controls
size B; Organization: LIGO Laboratory; Address1: California Institute of Technology; Address2: Massachusetts Institute of Technology; DocumentNumber: D1900511; Revision: V10; SheetNumber: 29; SheetTotal: 37; DrawnBy: R.  Abbott; Engineer: R.  Abbott; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.09¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=7¦PrintQuality=-4¦MediaType=1¦DitherType=10¦PaperKind=11x17¦PrintScaleMode=1

### Parts
C249  D25 Vacuum Feedthrough  Rack: HAM5  Slot: D5-1C1
C250  D25 Vacuum Feedthrough  Rack: HAM7  Slot: D8-F10
C251  D25 Vacuum Feedthrough  Rack: HAM7  Slot: D8-F11
C252  D25 Vacuum Feedthrough  Rack: HAM5  Slot: D5-1C2
C268  OFI/SFI TEC Interface  DCC: D2000503  Rack: SQZ-R2  Slot: U7
C300  Squeezer Oven Transl. & Cav. Piezo  DCC: D1700308  Rack: HAM7 ISI  Slot: On Table
C301  Squeezer Thermistor & IOPO TEC  DCC: D1700308  Rack: HAM7 ISI  Slot: On Table
C302  Squeezer DCPD & Lens Transl.  DCC: D1700308  Rack: HAM7 ISI  Slot: On Table
C303  Cable Bracket  DCC: D1700307  Rack: HAM7 ISI  Slot: On Table
C304  Cable Bracket  DCC: D1700306  Rack: HAM7 ISI  Slot: On Table
C305  Cable Bracket  DCC: D1700306  Rack: HAM7 ISI  Slot: On Table
C306  Cable Bracket  DCC: D1700306  Rack: HAM7 ISI  Slot: On Table
C307  D25 Vacuum Feedthrough  Rack: HAM7  Slot: D5-F5
C308  D25 Vacuum Feedthrough  Rack: HAM7  Slot: D5-F4
C309  D25 Vacuum Feedthrough  Rack: HAM7  Slot: D5-F6
C310  Squeezer Vac. Interface V2  DCC: D2100369  Rack: SQZ-R2  Slot: U8

### Ports
_Ties to Beckhoff, _Ties to RF Distribution, BDIV HAM7 (see SqueezerBeckhoff2[1C]), DCPD 1 (see SqueezerConcentrators[4C]), DCPD 2 (see SqueezerConcentrators[4C]), DCPD 3 (see SqueezerConcentrators[3B]), DCPD 4 (see SqueezerConcentrators[3B]), DCPD 5 (see SqueezerConcentrators[3B]), ISC_SQ_508 (see ISC_C2_SH2[2C]), OFI Therm. (see SqueezerBeckhoff2[3C]), OFI_TEC (see SqueezerBeckhoff2[3C]), OPO_TEC (see SqueezerBeckhoff2[3A]), Piezo 1 (see SqueezerRfControls1[5A]), Piezo 2 (see SqueezerRfControls1[5A]), SFI1 Therm. (see SqueezerBeckhoff2[3C]), SFI1_TEC (see SqueezerBeckhoff2[3C]), SFI2 Therm. (see SqueezerBeckhoff2[3C]), SFI2_TEC (see SqueezerBeckhoff2[3C]), Therm. 8_1 (see SqueezerBeckhoff2[3B]), Therm. 8_2 (see SqueezerBeckhoff2[3C]), Therm. 8_3 (see SqueezerBeckhoff2[3C])

### Nets
ISC_SQ_98: C310.SHV(Piezo_1) ; port Piezo 1
ISC_SQ_99: C310.SHV(Piezo_2) ; port Piezo 2
ISC_SQ_303: C307.D25M(Air_Side) C310.D25F(Cav._Piezo,_Oven_Transl.)
ISC_SQ_304: C308.D25M(Air_Side) C310.D25F(OPO_TEC_&_Thermistor)
ISC_SQ_305: C309.D25M(Air_Side) C310.D25F(DCPDs,_BDiv,_Lens_Transl.)
ISC_SQ_310: C310.D15M(EtherCat_TEC,_Therm_1) ; port OPO_TEC
ISC_SQ_327: C310.M12F(Therm_2) ; port Therm. 8_1
ISC_SQ_328: C310.M12F(Therm_3) ; port Therm. 8_2
ISC_SQ_329: C310.M12F(Therm_4) ; port Therm. 8_3
ISC_SQ_361: C310.TNC(DCPD_A) ; port DCPD 1
ISC_SQ_362: C310.TNC(DCPD_B) ; port DCPD 2
ISC_SQ_461: C310.TNC(DCPD_C) ; port DCPD 3
ISC_SQ_462: C310.TNC(DCPD_D) ; port DCPD 4
ISC_SQ_463: C310.TNC(DCPD_HAM5) ; port DCPD 5
ISC_SQ_481: C252.D25M(Vac._Side) C310.D25F(HAM5_OFI_DCPD)
ISC_SQ_482: C249.D25M(Vac._Side) C268.D25F(OFI)
ISC_SQ_483: C250.D25M(Vac._Side) C268.D25F(SFI1)
ISC_SQ_484: C251.D25M(Vac._Side) C268.D25F(SFI2)
ISC_SQ_487: C268.D15M(OFI_Peltier) ; port OFI_TEC
ISC_SQ_488: C268.D15M(SFI1_Peltier) ; port SFI1_TEC
ISC_SQ_489: C268.D15M(SFI2_Peltier) ; port SFI2_TEC
ISC_SQ_493: C268.M12F(Therm_3) ; port OFI Therm.
ISC_SQ_494: C268.M12F(Therm_1) ; port SFI1 Therm.
ISC_SQ_495: C268.M12F(Therm_2) ; port SFI2 Therm.
ISC_SQ_508: C310.D9M(Beam_Div._HAM5) ; port ISC_SQ_508
ISC_SQ_524: C310.D9M(Beam_Div._HAM7) ; port BDIV HAM7
VAC_SQ_011: C300.D9M(Oven_Transl._&_Cav._Piezo) C304.D25(DeviceSide)
VAC_SQ_012: C301.D9M(Squeezer_Thermistor_&_Peltier) C305.D25(DeviceSide)
VAC_SQ_013: C302.D9M(Squeezer_DCPD_&_Lens_Transl.) C303.D9(DeviceSide)
VAC_SQ_016: C303.D9(FlangeSide) C306.D25(DeviceSide)
VAC_SQ_017: C304.D25(FlangeSide) C307.D25M(Vac._Side)
VAC_SQ_018: C305.D25(FlangeSide) C308.D25M(Vac._Side)
VAC_SQ_019: C306.D25(FlangeSide) C309.D25M(Vac._Side)

### Layout directives
DCC: D1700438: VAC_SQ_011
DCC: D1700439: VAC_SQ_012
DCC: D1700440: VAC_SQ_013
DCC: D1700308: VAC_SQ_016
Length: 70ft: ISC_SQ_303, ISC_SQ_304, ISC_SQ_305, ISC_SQ_483, ISC_SQ_484
Length: 260 Inches: VAC_SQ_017, VAC_SQ_018, VAC_SQ_019
DCC: D1700316: VAC_SQ_017, VAC_SQ_018, VAC_SQ_019
Length: 6ft: VAC_SQ_011, VAC_SQ_012, VAC_SQ_016
Length: 2ft: VAC_SQ_013
Length: 90ft: ISC_SQ_481, ISC_SQ_482

### Notes on the sheet
- OFI 2
- SFI 1
- SFI 2
- (near C310) Not compatible with LIGO picomotor driver
- (near C302) Beam diverter
- HAM5 DCPD
- Oven
- Witness
- Bottom Reservoir
- Unused
- D1700308 Wiring Diagram - More Cables
- |   LHO         |   LLO
  -----------------------------------------
  DCPD A    |   Green pump  |   Green pump
  DCPD B    |   Red CLF     |   Red CLF
  DCPD C    |   Green FC    |   Green FC
  DCPD D    |   OFI_A HAM7  |   OFI_A HAM7
  DCPP HAM5 |   OFI_B HAM5  |   OFI_B HAM5
  -----------------------------------------
- Key
- Dot Identifies Cable Shield Terminating to Backshell
- Pin With Triangle Indicates Pin on Rear or the Like
- Pin With No Triangle Indicates Pin on Front or the Like
- Light Blue Symbols Are In-Vacuum
- Yellow Symbols Are In-Air

### Library data of the parts
C249-C252 C307-C309 = VacFeedD25: Serial: Sxxxxxxx; System: ISC
C268 = OFI/SFI TEC Interface: Serial: Sxxxxxxx; System: ISC
C300 = Squeezer Oven Transl. & Cav. Piezo: Serial: Sxxxxxxx; System: ISC
C301 = Squeezer Thermistor & Peltier: Serial: Sxxxxxxx; System: ISC
C302 = Squeezer DCPD & Lens Transl.: Serial: Sxxxxxxx; System: ISC
C303 = CabBracket_D9: Serial: Sxxxxxxx; System: ISC
C304-C306 = CabBracket_D25: Serial: Sxxxxxxx; System: ISC
C310 = Squeezer Vac. Interface V2: Serial: Sxxxxxxx; System: ISC